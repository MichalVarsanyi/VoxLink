File: Hardware/VoxLink.kicad_sch (KiCad schematic)
At the start: 31 parts, among them U1 ICE40UL1K-SWG16, U2 TPS7A20L_1V2, U3 TPS7A20L_2V2, U4 MIC5205-3.3YM5-TR, U5 TPS7A20L_3V3

Commit message: Created the Hardware Design section outlining the hardware design process. Added section for controlled impedance calculation and included a High Level Overview section with a block diagram of the system architecture. The changes to the KiCad files are minimal and were not of concern for this commit.
Parts:
- removed C18, C20: 1u, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed C19, C21: 100n, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed C22: 470p, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed U1: ICE40UL1K-SWG16, Package_CSP:WLCSP-16_1.409x1.409mm_Layout4x4_P0.35mm, symbol FPGA_Lattice:ICE40UL1K-SWG16
- removed U4: MIC5205-3.3YM5-TR, Package_TO_SOT_SMD:SOT-23-5, symbol Regulator_Linear:MIC5205-4.0YM5
- added U1: FT2232HQ, Package_DFN_QFN:QFN-64-1EP_9x9mm_P0.5mm_EP4.35x4.35mm, symbol Interface_USB:FT2232HQ
Connections:
- net +4V is gone; now on net +5V: C1.1, C6.1, C9.1, U2.3 (EN), U2.4 (IN), U3.3 (EN), U3.4 (IN), U5.3 (EN), U5.4 (IN)

Commit message: Finished the FPGA Pinout in KiCad and started routing the Power section. Created the TinyFPGA_BringUp project in iCEcube2 IDE to test familiarize myself with the Lattice toolchain.
Parts:
- removed U1: FT2232HQ, Package_DFN_QFN:QFN-64-1EP_9x9mm_P0.5mm_EP4.35x4.35mm, symbol Interface_USB:FT2232HQ
Other:
- added sheet Power (power.kicad_sch)
Changed lines of the file:
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@@
-	)
-	(symbol
-		(lib_id "Interface_USB:FT2232HQ")
-		(at 63.5 85.09 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(fields_autoplaced yes)
-		(property "Reference" "U1"
-			(at 78.3433 27.94 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-			)
-		)
-		(property "Value" "FT2232HQ"
-			(at 78.3433 30.48 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-			)
-		)
-		(property "Footprint" "Package_DFN_QFN:QFN-64-1EP_9x9mm_P0.5mm_EP4.35x4.35mm"
-			(at 63.5 85.09 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" "https://www.ftdichip.com/Support/Documents/DataSheets/ICs/DS_FT2232H.pdf"
-			(at 63.5 85.09 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Hi Speed Double Channel USB UART/FIFO, QFN-64"
-			(at 63.5 85.09 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "63"
-		)
-		(pin "50"
-		)
-		(pin "5"
-		)
-		(pin "51"
-		)
-		(pin "35"
-		)
-		(pin "20"
-		)
-		(pin "37"
-		)
-		(pin "8"
-		)
-		(pin "7"
-		)
-		(pin "14"
-		)
-		(pin "2"
-		)
-		(pin "3"
-		)
-		(pin "10"
-		)
-		(pin "12"
-		)
-		(pin "61"
-		)
-		(pin "15"
-		)
-		(pin "4"
-		)
-		(pin "49"
-		)
-		(pin "9"
-		)
-		(pin "64"
-		)
-		(pin "25"
-		)
-		(pin "31"
-		)
-		(pin "6"
-		)
-		(pin "11"
-		)
-		(pin "62"
-		)
-		(pin "1"
-		)
-		(pin "13"
-		)
-		(pin "47"
-		)
-		(pin "38"
-		)
-		(pin "40"
-		)
-		(pin "43"
-		)
-		(pin "22"
-		)
-		(pin "48"
-		)
-		(pin "65"
-		)
-		(pin "52"
-		)
-		(pin "17"
-		)
-		(pin "27"
-		)
-		(pin "30"
-		)
-		(pin "46"
-		)
-		(pin "29"
-		)
-		(pin "16"
-		)
-		(pin "56"
-		)
-		(pin "18"
-		)
-		(pin "23"
-		)
-		(pin "24"
-		)
-		(pin "28"
-		)
-		(pin "21"
-		)
-		(pin "19"
-		)
-		(pin "26"
-		)
-		(pin "32"
-		)
-		(pin "42"
-		)
-		(pin "33"
-		)
-		(pin "34"
-		)
-		(pin "39"
-		)
-		(pin "41"
-		)
-		(pin "44"
-		)
-		(pin "45"
-		)
-		(pin "54"
-		)
-		(pin "53"
-		)
-		(pin "55"
-		)
-		(pin "57"
-		)
-		(pin "58"
-		)
-		(pin "59"
-		)
-		(pin "60"
-		)
-		(pin "36"
-		)
-		(instances
-			(project ""
-				(path "/ded7c4da-7d9f-418d-838f-f5efc7d9c9cb"
-					(reference "U1")
-					(unit 1)
-				)
-			)
-		)
 	)
 	(symbol
@@
 				)
 			)
+		)
+	)
+	(sheet
+		(at 86.614 39.878)
+		(size 51.054 34.29)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(stroke
+			(width 0.1524)
+			(type solid)
+		)
+		(fill
+			(color 0 0 0 0.0000)
+		)
+		(property "Sheetname" "Power"
+			(at 86.614 39.1664 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left bottom)
+			)
+		)
+		(property "Sheetfile" "power.kicad_sch"
+			(at 86.614 74.7526 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left top)
+			)
+		)
+		(instances
+			(project "VoxLink"
+				(path "/ded7c4da-7d9f-418d-838f-f5efc7d9c9cb"
+					(page "2")
+				)
+			)

Commit message: Added schematic sections and advanced the design. Advanced the development of Verilog code, for TinyFPGA bringup (however, still not working). Cosmetic changes in README.
Parts:
- removed C1, C10, C2, C6, C7, C9: 1u, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed C11, C12, C13, C14, C15, C3, C4, C5, C8: 100n, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed FB1, FB2, FB3: 120R, Capacitor_SMD:C_0402_1005Metric, symbol Device:FerriteBead
- removed L1, L2, L3: 2n2, Inductor_SMD:L_0402_1005Metric, symbol Device:L
- removed U2: TPS7A20L_1V2, Package_SON:Texas_X2SON-4_1x1mm_P0.65mm, symbol Regulator_Linear:TPS7A20xxxDQN
- removed U3: TPS7A20L_2V2, Package_SON:Texas_X2SON-4_1x1mm_P0.65mm, symbol Regulator_Linear:TPS7A20xxxDQN
- removed U5: TPS7A20L_3V3, Package_SON:Texas_X2SON-4_1x1mm_P0.65mm, symbol Regulator_Linear:TPS7A20xxxDQN
Other:
- added sheet Sensor (Sensor.kicad_sch)
- added sheet System (System.kicad_sch)
- note added: "Root [1]"
- company: (none) -> Czech Technical University in Prague
- title: (none) -> Root
