File: Hardware/Sensor_Board/VoxSense.kicad_pcb (KiCad board)
At the start: 4 copper layers, 92 parts, among them J3 RJ45_Output, J302 TC2030, J303 PicoBlade, J4 RJ45_Input, SW1 Slide Switch, SW301 Reset, U10 TPD4E02B04, U101 TPS25942ARVCR, U11 CBTU02044, U201 TPS7A20L_1V2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

Commit message: Routing and Schematic update
Parts:
- removed R5: 10k, Resistor_SMD:R_0402_1005Metric
- added D1: D_Schottky, Diode_SMD:D_0402_1005Metric, F.Cu at (95.4, 73.8)
- J302: value TC2030 -> TC2030-NL; footprint Connector:Tag-Connect_TC2030-IDC-FP_2x03_P1.27mm_Vertical -> Connector:Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
- Y301: footprint Oscillator:Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm -> Oscillator:Oscillator_SMD_Abracon_ASCO-4Pin_1.6x1.2mm
- moved D4 36.6 mm to (132.1, 79.9), turned to 180 degrees
- moved J303 27.1 mm to (104.5, 69.8)
- moved D301 26.5 mm to (95.4, 71.8)
- moved J302 25.0 mm to (100.0, 73.0)
- moved C301 24.0 mm to (95.4, 72.8)
- moved U302 23.0 mm to (104.4, 73.6)
- moved R301 22.9 mm to (106.3, 72.0)
- moved R302 22.9 mm to (106.3, 73.0)
- moved R304 22.9 mm to (106.3, 75.0)
- moved R303 22.9 mm to (106.3, 74.0)
- moved C303 20.2 mm to (108.7, 71.8), turned to -90 degrees
- moved Y301 17.5 mm to (110.1, 71.8)
- moved R311 15.9 mm to (110.1, 73.4), turned to 180 degrees
- moved R106 15.5 mm to (94.6, 79.9), turned to 0 degrees
- moved R102 14.5 mm to (96.0, 75.6)
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Connections:
- net /Connectivity/VOX_RX_OUT renamed /Connectivity/VOX_RX_OUT_P
- net /Connectivity/~{VOX_RX_OUT} renamed /Connectivity/VOX_RX_OUT_N
- net Net-(U305-~{HOLD}) renamed /System/FLASH_~{HOLD}
- net Net-(U305-~{WP}) renamed /System/FLASH_~{WP}
- C301 pad 1: VCC -> VCCD
- D301 pad 1: VCC -> VCCD
- J3 pad 7: /Connectivity/VOX_TX_NOESD_OUT -> /Connectivity/~{VOX_TX}_NOESD_OUT
- J3 pad 8: /Connectivity/~{VOX_TX}_NOESD_OUT -> /Connectivity/VOX_TX_NOESD_OUT
- J302 pad 1: VCC -> VCCD
- J303 pad 8: VCC -> VCCD
- J4 pad 1: /Connectivity/VOX_RX_NOESD_IN -> /Connectivity/VOX_RX_NOESD_IN_P
- J4 pad 2: /Connectivity/~{VOX_RX}_NOESD_IN -> /Connectivity/VOX_RX_NOESD_IN_N
- J4 pad 4: /Connectivity/VOX_CLK_NOESD_IN -> /Connectivity/VOX_CLK_NOESD_IN_P
- J4 pad 5: /Connectivity/~{VOX_CLK}_NOESD_IN -> /Connectivity/VOX_CLK_NOESD_IN_N
- J4 pad 7: /Connectivity/VOX_TX_NOESD_IN -> /Connectivity/VOX_TX_NOESD_IN_N
- J4 pad 8: /Connectivity/~{VOX_TX}_NOESD_IN -> /Connectivity/VOX_TX_NOESD_IN_P
- SW1 pad 2: Net-(SW1-CNT) -> /Connectivity/ARCHITECTURE_SEL
- U10 pad 1: /Connectivity/VOX_RX_NOESD_IN -> unconnected-(U10-IN-Pad1)
- U10 pad 10: /Connectivity/VOX_RX_P -> unconnected-(U10-NC-Pad10)
- U10 pad 2: /Connectivity/~{VOX_RX}_NOESD_IN -> unconnected-(U10-IN-Pad2)
- U10 pad 4: unconnected-(U10-IN-Pad4) -> /Connectivity/VOX_RX_NOESD_IN_N
- U10 pad 5: unconnected-(U10-IN-Pad5) -> /Connectivity/VOX_RX_NOESD_IN_P
- U10 pad 6: unconnected-(U10-NC-Pad6) -> /Connectivity/VOX_RX_P
- U10 pad 7: unconnected-(U10-NC-Pad7) -> /Connectivity/VOX_RX_N
- U10 pad 9: /Connectivity/VOX_RX_N -> unconnected-(U10-NC-Pad9)
- U3 pad 1: /Connectivity/VOX_CLK_NOESD_IN -> /Connectivity/VOX_TX_NOESD_IN_N
- U3 pad 10: /Connectivity/VOX_CLK_P -> /Connectivity/VOX_TX_N
- U3 pad 2: /Connectivity/~{VOX_CLK}_NOESD_IN -> /Connectivity/VOX_TX_NOESD_IN_P
- U3 pad 4: /Connectivity/VOX_TX_NOESD_IN -> /Connectivity/VOX_CLK_NOESD_IN_P
- U3 pad 5: /Connectivity/~{VOX_TX}_NOESD_IN -> /Connectivity/VOX_CLK_NOESD_IN_N
- U3 pad 6: /Connectivity/VOX_TX_N -> /Connectivity/VOX_CLK_N
- U3 pad 7: /Connectivity/VOX_TX_P -> /Connectivity/VOX_CLK_P
- U3 pad 9: /Connectivity/VOX_CLK_N -> /Connectivity/VOX_TX_P
- U302 pad 1: /System/FLASH_~{CS}_NOESD -> /System/FLASH_SCK_NOESD
- U302 pad 10: Net-(R301-Pad2) -> Net-(R304-Pad2)
- U302 pad 2: /System/FLASH_MOSI_NOESD -> /System/FLASH_MISO_NOESD
- U302 pad 4: /System/FLASH_MISO_NOESD -> /System/FLASH_MOSI_NOESD
- U302 pad 5: /System/FLASH_SCK_NOESD -> /System/FLASH_~{CS}_NOESD
- U302 pad 6: Net-(R304-Pad2) -> Net-(R301-Pad2)
- U302 pad 7: Net-(R303-Pad2) -> Net-(R302-Pad2)
- U302 pad 9: Net-(R302-Pad2) -> Net-(R303-Pad2)
Routing:
- net VCC: track 0.00 -> 109.8 mm
- net /Connectivity/VOX_RX_OUT_P: track 0.00 -> 53.9 mm, vias 0 -> 2
- net /Connectivity/VOX_RX_OUT_N: track 0.00 -> 52.9 mm, vias 0 -> 2
- net /Connectivity/VOX_RX_N: track 0.88 -> 50.7 mm, vias 0 -> 2
- net /Connectivity/VOX_RX_P: track 0.89 -> 50.3 mm, vias 0 -> 2
- net /Connectivity/VOX_CLK_P: track 0.86 -> 49.0 mm, vias 0 -> 2
- net /Connectivity/VOX_CLK_N: track 0.84 -> 48.2 mm, vias 0 -> 2
- net /Connectivity/VOX_TX_FPGA_N: track 0.00 -> 29.6 mm, vias 0 -> 2
- net /Connectivity/VOX_TX_FPGA_P: track 0.00 -> 29.1 mm, vias 0 -> 2
- net GND: track 4.13 -> 27.7 mm, vias 4 -> 35
- net /Connectivity/VOX_CLK_NOESD_IN_N: track 0.00 -> 17.4 mm
- net /Connectivity/VOX_CLK_NOESD_IN_P: track 0.00 -> 17.1 mm
- net /Connectivity/ARCHITECTURE_SEL: track 0.00 -> 13.0 mm, vias 0 -> 2
- net /Connectivity/VOX_TX_P: track 0.00 -> 12.6 mm, vias 0 -> 1
- net /Connectivity/VOX_TX_N: track 0.00 -> 12.3 mm, vias 0 -> 1
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Other:
- board outline added: 85 x 15.7 mm

Commit message: Finised the design of the sensor board :)
Parts:
- removed R3: 0R, Resistor_SMD:R_0402_1005Metric
- removed the R302 at (106.3, 73.0)
- removed the R303 at (106.3, 74.0)
- removed the R304 at (106.3, 75.0)
- added G***: LOGO, LOGO, F.Cu at (119.5, 79.6)
- added R503: 0R, Resistor_SMD:R_0402_1005Metric, F.Cu at (131.9, 70.2)
- added TP501: TestPoint, Custom_VoxLink_Footprints:Vox_Testpoint, B.Cu at (90.1, 69.0)
- added TP502: TestPoint, Custom_VoxLink_Footprints:Vox_Testpoint, B.Cu at (89.6, 68.5)
- D302: renamed from D1; value D_Schottky -> Schottky
- R301: value 22R -> 4x22R; footprint Resistor_SMD:R_0402_1005Metric -> Custom_VoxLink_Footprints:EXBN8V101JX
- moved R403 8.31 mm to (121.6, 67.5), turned to -90 degrees
- moved R504 8.11 mm to (131.9, 75.3), turned to -90 degrees
- moved R502 6.54 mm to (131.9, 72.0), turned to -90 degrees
- moved C405 2.53 mm to (120.8, 77.5), turned to 180 degrees
- moved C404 2.52 mm to (123.2, 77.5), turned to 0 degrees
- moved D502 1.57 mm to (131.9, 78.3), turned to 90 degrees
- moved D307 1.51 mm to (124.7, 67.5)
- moved R307 1.50 mm to (123.2, 69.9)
- moved R308 1.50 mm to (124.7, 69.9)
- moved D306 1.49 mm to (123.2, 67.5)
- moved C502 1.36 mm to (93.3, 70.2)
- moved R301 1.24 mm to (106.3, 73.2), turned to 90 degrees
- moved U503 1.18 mm to (130.5, 71.1)
- moved U504 1.18 mm to (130.5, 74.6)
- moved D303 1.14 mm to (108.8, 66.3), turned to 90 degrees
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- renumbered C1 to C501, C3 to C502, D302 to D303, D303 to D304, D304 to D308, D3 to D501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
Connections:
- net Net-(U11-C0_N) renamed /Connectivity/VOX_RX_T_N
- net Net-(U11-C0_P) renamed /Connectivity/VOX_RX_T_P
- J501 pad 1: /Connectivity/VOX_RX_NOESD_IN_P -> /Connectivity/VOX_RX_P
- J501 pad 2: /Connectivity/VOX_RX_NOESD_IN_N -> /Connectivity/VOX_RX_N
- J501 pad 4: /Connectivity/VOX_CLK_NOESD_IN_P -> /Connectivity/VOX_CLK_P
- J501 pad 5: /Connectivity/VOX_CLK_NOESD_IN_N -> /Connectivity/VOX_CLK_N
- J501 pad 7: /Connectivity/VOX_TX_NOESD_IN_N -> /Connectivity/VOX_TX_N
- J501 pad 8: /Connectivity/VOX_TX_NOESD_IN_P -> /Connectivity/VOX_TX_P
- J502 pad 1: /Connectivity/VOX_RX_NOESD_OUT -> /Connectivity/VOX_RX_OUT_P
- J502 pad 2: /Connectivity/~{VOX_RX}_NOESD_OUT -> /Connectivity/VOX_RX_OUT_N
- J502 pad 4: /Connectivity/VOX_CLK_NOESD_OUT -> /Connectivity/VOX_CLK_P
- J502 pad 5: /Connectivity/~{VOX_CLK}_NOESD_OUT -> /Connectivity/VOX_CLK_N
- J502 pad 7: /Connectivity/~{VOX_TX}_NOESD_OUT -> /Connectivity/VOX_TX_N
- J502 pad 8: /Connectivity/VOX_TX_NOESD_OUT -> /Connectivity/VOX_TX_P
- R301 pad 2: Net-(R301-Pad2) -> /System/FLASH_MOSI
- R502 pad 1: /Connectivity/~{VOX_CLK}_NOESD_OUT -> /Connectivity/VOX_CLK_P
- R502 pad 2: GND -> /Connectivity/VOX_CLK_N
- R504 pad 1: /Connectivity/~{VOX_TX}_NOESD_OUT -> /Connectivity/VOX_RX_OUT_N
- R504 pad 2: GND -> /Connectivity/VOX_RX_OUT_P
- U301 pad C2: unconnected-(U301C-IOT_27A-PadC2) -> GND
- U302 pad 10: Net-(R304-Pad2) -> /System/FLASH_SCK_NOESD
- U302 pad 6: Net-(R301-Pad2) -> /System/FLASH_~{CS}_NOESD
- U302 pad 7: Net-(R302-Pad2) -> /System/FLASH_MOSI_NOESD
- U302 pad 9: Net-(R303-Pad2) -> /System/FLASH_MISO_NOESD
- U501 pad 1: /Connectivity/VOX_TX_NOESD_IN_N -> /Connectivity/VOX_TX_N
- U501 pad 2: /Connectivity/VOX_TX_NOESD_IN_P -> /Connectivity/VOX_TX_P
- U501 pad 4: /Connectivity/VOX_CLK_NOESD_IN_P -> /Connectivity/VOX_CLK_P
- U501 pad 5: /Connectivity/VOX_CLK_NOESD_IN_N -> /Connectivity/VOX_CLK_N
- U502 pad 4: /Connectivity/VOX_RX_NOESD_IN_N -> /Connectivity/VOX_RX_N
- U502 pad 5: /Connectivity/VOX_RX_NOESD_IN_P -> /Connectivity/VOX_RX_P
- U503 pad 1: /Connectivity/VOX_CLK_NOESD_OUT -> /Connectivity/VOX_CLK_N
- U503 pad 10: /Connectivity/VOX_CLK_P -> /Connectivity/VOX_CLK_N
- U503 pad 2: /Connectivity/~{VOX_CLK}_NOESD_OUT -> /Connectivity/VOX_CLK_P
- U503 pad 4: /Connectivity/VOX_TX_NOESD_OUT -> /Connectivity/VOX_TX_P
- U503 pad 5: /Connectivity/~{VOX_TX}_NOESD_OUT -> /Connectivity/VOX_TX_N
- U503 pad 9: /Connectivity/VOX_CLK_N -> /Connectivity/VOX_CLK_P
- U504 pad 1: /Connectivity/VOX_RX_NOESD_OUT -> /Connectivity/VOX_RX_OUT_P
- U504 pad 2: /Connectivity/~{VOX_RX}_NOESD_OUT -> /Connectivity/VOX_RX_OUT_N
Routing:
- net +3V3: track 7.41 -> 177.8 mm, vias 0 -> 11
- net /Connectivity/VOX_TX_P: track 12.6 -> 84.2 mm, vias 1 -> 4
- net /Connectivity/VOX_TX_N: track 12.3 -> 83.9 mm, vias 1 -> 4
- net GND: track 27.7 -> 71.7 mm, vias 35 -> 67
- net /System/CDONE: track 0.74 -> 41.1 mm, vias 0 -> 3
- net /Connectivity/VOX_CLK_N: track 48.2 -> 86.3 mm, vias 2 -> 3
- net /Connectivity/VOX_CLK_P: track 49.0 -> 85.8 mm, vias 2 -> 3
- net ~{CRESET}: track 8.83 -> 42.4 mm, vias 2 -> 3
- net +5V: track 2.99 -> 27.6 mm, vias 0 -> 3
- net +1V2_CORE: track 2.45 -> 25.7 mm, vias 1 -> 4
- net BNO_~{RST}: track 0.74 -> 23.8 mm, vias 0 -> 2
- net /Connectivity/VOX_CLK_NOESD_IN_N: track 17.4 -> 0.00 mm
- net /System/FLASH_~{CS}: track 5.43 -> 22.7 mm, vias 0 -> 2
- net /Connectivity/VOX_CLK_NOESD_IN_P: track 17.1 -> 0.00 mm
- net /System/LED: track 0.81 -> 17.6 mm, vias 0 -> 2
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Other:
- board text added: "BUS"
- board text added: "CD"
- board text added: "DAISY"
- board text added: "Designed by Michal Varsanyi"
- board text added: "IN"
- board text added: "LD"
- board text added: "OUT"
- board text added: "RST"
- board text added: "RX"
- board text added: "TX"
- board text removed: "Add ESD Protection!"
- board text removed: "Make into resistor array: EXB-38V220JV"

Commit message: Finished design of both programmer and sensor board PCBs
Parts:
- added D102: Schottky, Diode_SMD:D_0402_1005Metric, F.Cu at (90.1, 79.3)
- added D103: Schottky, Diode_SMD:D_0402_1005Metric, F.Cu at (103.1, 76.4)
- R105: value 10k -> 1k
- moved R101 0.06 mm to (92.1, 79.6)
- moved C101 0.06 mm to (92.5, 76.6)
Connections:
- C103 pad 2: GND -> Net-(D102-A)
- R104 pad 1: GND -> Net-(D102-A)
- R106 pad 1: GND -> Net-(D102-A)
- U101 pad 1: GND -> Net-(D102-A)
- U101 pad 16: GND -> Net-(D102-A)
- U101 pad 21: GND -> Net-(D102-A)
Routing:
- net Net-(D102-A): track 0.00 -> 16.6 mm
- net GND: track 71.7 -> 83.7 mm, vias 67 -> 64

Commit message: Finished final PCB checks before manufacturing and uploaded the fabrication files
Parts:
- U302, U501, U502, U503, U504: footprint Package_SON:USON-10_2.5x1.0mm_P0.5mm -> Custom_VoxLink_Footprints:USON-10_2.5x1.0mm_P0.5mm__Reduced_Paste
Routing:
- net GND: vias 64 -> 94

Commit message: Updated documentation and finished first iteration of PCB rework based on manufacturer feedback.
Parts:
- U301: footprint Custom_VoxLink_Footprints:ICE40UL1K_UCBGA-36 -> Package_BGA:UCBGA-36_2.5x2.5mm_Layout6x6_P0.4mm
Connections:
- U301 pad C2: GND -> unconnected-(U301C-IOT_27A-PadC2)
- U301 pad D2: +1V2_CORE -> unconnected-(U301B-IOB_8A_G4-PadD2)
Routing:
- net GND: track 83.7 -> 79.9 mm, vias 94 -> 96
- net /System/CDONE: track 41.1 -> 38.3 mm
- net /Connectivity/VOX_RX_N: track 41.8 -> 39.8 mm
- net /Connectivity/VOX_RX_P: track 42.4 -> 40.4 mm
- net +3V3: track 177.9 -> 179.7 mm, vias 11 -> 13
- net +1V2_CORE: track 25.7 -> 24.7 mm
- net /System/FLASH_MISO: track 17.8 -> 16.8 mm, vias 2 -> 3
- net +2V5_NVCM: track 6.01 -> 6.02 mm, vias 0 -> 2
