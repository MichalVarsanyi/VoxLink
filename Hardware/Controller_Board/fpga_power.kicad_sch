File: Hardware/Controller_Board/fpga_power.kicad_sch (KiCad schematic)
At the start: 59 parts, among them U1 XC7A35T-CPG236

Commit message: Commited Schematic Changes
Parts:
- U1: footprint (none) -> Package_BGA:Xilinx_CPG236
Other:
- note added: "FPGA Power [2]"
- moved on the sheet: C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25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

Commit message: Updated schematic diagram with configuration
Changed lines of the file:
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@@
 		(pin "L7"
+		)
+		(pin "V11"
+		)
+		(pin "A12"
+		)
+		(pin "B13"
+		)
+		(pin "V12"
+		)
+		(pin "V10"
+		)
+		(pin "B12"
+		)
+		(pin "A13"
+		)
+		(pin "A11"
+		)
+		(pin "W11"
+		)
+		(pin "C11"
+		)
+		(pin "U11"
+		)
+		(pin "W8"
+		)
+		(pin "F18"
+		)
+		(pin "D18"
+		)
+		(pin "W9"
+		)
+		(pin "W10"
+		)
+		(pin "K19"
+		)
+		(pin "C8"
+		)
+		(pin "D19"
+		)
+		(pin "U12"
+		)
+		(pin "B11"
+		)
+		(pin "U10"
+		)
+		(pin "G18"
 		)
 		(instances

Commit message: Added new sheets to the schematic
Parts:
- removed FB2: 600R/100MHz, symbol Device:FerriteBead
Connections:
- net AGND is gone; now on net GND: C15.2, U1.C12 (GNDADC_0)
Changed lines of the file:
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@@
 		)
 	)
+	(text_box "FPGA Power"
+		(exclude_from_sim no)
+		(at 17.78 41.91 0)
+		(size 262.89 115.57)
+		(margins 1.5 1.5 1.5 1.5)
+		(stroke
+			(width 0)
+			(type dash)
+		)
+		(fill
+			(type none)
+		)
+		(effects
+			(font
+				(size 2 2)
+				(thickness 0.4)
+				(bold yes)
+			)
+			(justify left top)
+		)
+	)
 	(junction
 		(at 25.4 77.47)
@@
 	)
 	(junction
-		(at 149.86 153.67)
-		(diameter 0)
-		(color 0 0 0 0)
-	)
-	(junction
 		(at 171.45 62.23)
 		(diameter 0)
@@
 	(wire
 		(pts
-			(xy 149.86 153.67) (xy 149.86 154.94)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 171.45 129.54) (xy 171.45 132.08)
 		)
@@
 	(wire
 		(pts
-			(xy 161.29 153.67) (xy 165.1 153.67)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 223.52 129.54) (xy 233.68 129.54)
 		)
@@
 	(wire
 		(pts
-			(xy 149.86 153.67) (xy 153.67 153.67)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 182.88 129.54) (xy 193.04 129.54)
 		)
@@
 	(wire
 		(pts
-			(xy 149.86 149.86) (xy 149.86 153.67)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 193.04 129.54) (xy 203.2 129.54)
 		)
@@
 	(wire
 		(pts
-			(xy 165.1 153.67) (xy 165.1 154.94)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 125.73 142.24) (xy 124.46 142.24)
 		)
@@
 	)
 	(symbol
-		(lib_id "Device:FerriteBead")
-		(at 157.48 153.67 90)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(property "Reference" "FB2"
-			(at 157.48 148.082 90)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-			)
-		)
-		(property "Value" "600R/100MHz"
-			(at 157.48 149.86 90)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-			)
-		)
-		(property "Footprint" ""
-			(at 157.48 155.448 90)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" "~"
-			(at 157.48 153.67 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Ferrite bead"
-			(at 157.48 153.67 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "2"
-		)
-		(pin "1"
-		)
-		(instances
-			(project "Controller_Board"
-				(path "/4e6e1af1-ede9-4a56-9d5f-a8dfd7fbcf8d/77637722-5c93-4eaa-a1cc-47897016a2a9"
-					(reference "FB2")
-					(unit 1)
-				)
-			)
-		)
-	)
-	(symbol
 		(lib_id "Device:C")
 		(at 271.78 81.28 0)
@@
 	)
 	(symbol
+		(lib_id "power:GND")
+		(at 114.3 71.12 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(property "Reference" "#PWR035"
+			(at 114.3 77.47 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Value" "GND"
+			(at 114.3 74.676 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Footprint" ""
+			(at 114.3 71.12 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" ""
+			(at 114.3 71.12 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
+			(at 114.3 71.12 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "Controller_Board"
+				(path "/4e6e1af1-ede9-4a56-9d5f-a8dfd7fbcf8d/77637722-5c93-4eaa-a1cc-47897016a2a9"
+					(reference "#PWR035")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
 		(lib_id "power:+1V8")
 		(at 124.46 68.58 0)
@@
 	)
 	(symbol
-		(lib_id "power:Earth")
-		(at 149.86 154.94 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(property "Reference" "#PWR035"
-			(at 149.86 161.29 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Value" "AGND"
-			(at 149.86 158.75 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-			)
-		)
-		(property "Footprint" ""
-			(at 149.86 154.94 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" "~"
-			(at 149.86 154.94 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Power symbol creates a global label with name \"Earth\""
-			(at 149.86 154.94 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "1"
-		)
-		(instances
-			(project ""
-				(path "/4e6e1af1-ede9-4a56-9d5f-a8dfd7fbcf8d/77637722-5c93-4eaa-a1cc-47897016a2a9"
-					(reference "#PWR035")
-					(unit 1)
-				)
-			)
-		)
-	)
-	(symbol
 		(lib_id "Device:C")
 		(at 114.3 118.11 0)
@@
 	)
 	(symbol
-		(lib_id "power:Earth")
-		(at 114.3 71.12 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(property "Reference" "#PWR036"
-			(at 114.3 77.47 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Value" "AGND"
-			(at 114.3 74.93 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-			)
-		)
-		(property "Footprint" ""
-			(at 114.3 71.12 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" "~"
-			(at 114.3 71.12 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Power symbol creates a global label with name \"Earth\""
-			(at 114.3 71.12 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "1"
-		)
-		(instances
-			(project "Controller_Board"
-				(path "/4e6e1af1-ede9-4a56-9d5f-a8dfd7fbcf8d/77637722-5c93-4eaa-a1cc-47897016a2a9"
-					(reference "#PWR036")
-					(unit 1)
-				)
-			)
-		)
-	)
-	(symbol
 		(lib_id "power:GND")
 		(at 104.14 104.14 0)
@@
 	(symbol
 		(lib_id "power:GND")
-		(at 165.1 154.94 0)
+		(at 149.86 149.86 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR040"
-			(at 165.1 161.29 0)
+			(at 149.86 156.21 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND"
-			(at 165.1 158.496 0)
+			(at 149.86 153.416 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 165.1 154.94 0)
+			(at 149.86 149.86 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 165.1 154.94 0)
+			(at 149.86 149.86 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 165.1 154.94 0)
+			(at 149.86 149.86 0)
 			(effects
 				(font

Commit message: Added USB hub symbol
Parts:
- renumbered C14 to C17, C15 to C18, C46 to C19, C47 to C20, C59 to C21, C60 to C22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
