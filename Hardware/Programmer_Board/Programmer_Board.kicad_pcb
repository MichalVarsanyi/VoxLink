# Repository MichalVarsanyi/VoxLink (continued)

## KiCad design Hardware/Programmer_Shell_Module/Programmer_Shell_Module.kicad_pcb

Parts:
C1: 1u; C_0603_1608Metric
C2: 10u; C_1206_3216Metric
H801, H802, H803, H804: M3; MountingHole_3.2mm_M3_Pad_Via
J2: RJ45_Output; CONN_855035-101_MOL
R1: 10k; R_0603_1608Metric
R2: 20k; R_0603_1608Metric
R3: 1R; R_0603_1608Metric
U1: VoxLink_Core_Module

Connections:
+5V: C2.1, J2.5 (~CLK), R1.1, U1.26 (5V)
/DONE: J2.6 (GND), U1.2 (DONE)
/FLASH_MISO: J2.8 (TX), U1.5 (FLASH_MISO)
/FLASH_MOSI: J2.7 (~TX), U1.3 (FLASH_MOSI)
/FLASH_NCS: J2.4 (CLK), U1.6 (FLASH_NSC)
/FLASH_SCK: J2.3 (VCC), U1.4 (FLASH_SCK)
/NRESET: C1.1, J2.1 (RX), R1.2, R2.1, U1.1 (NRESET)
GND: C1.2, H801.1 (1_1), H802.1 (1_1), H803.1 (1_1), H804.1 (1_1), J2.2 (~RX), J2.9 (SHD), J2.10 (SHD), R2.2, R3.2, U1.27 (GND)
unnamed: C2.2, R3.1

Notes on the sheet:
Programmer color coding conversion to VoxLink with the BotBlox 8-way cable
VoxLink Programmer Shell
M3 Mounting Holes
Lattice Core Module

Board: 4 copper layers, 70.0 x 70.0 mm, 11 parts (0 on the bottom side), 9 nets.

## KiCad design Hardware/Core_Module/Core_Module.kicad_pcb

Notes on the sheet:
Technical Sheet Only! Please refer to the subsequent sheets for schematic
Root [0]

Parts:
C101, C103, C107, C112, C113, C116: 100n; C_0201_0603Metric; LCSC C668346
C104, C105, C108, C109, C114, C115: 1u; C_0201_0603Metric; LCSC C335102
C110: 2.2u; C_0201_0603Metric; LCSC C335106
D101: LED; LED_0201_0603Metric; LCSC C5846955
D102: LED; LED_0201_0603Metric; LCSC C4153580
R101: 22R; R_0201_0603Metric; LCSC C3009113
R103, R106: 499R; R_0201_0603Metric; LCSC C2094902
R104, R105: 10k; R_0201_0603Metric; LCSC C844303
U101: TPS7A20L_1V2; Texas_X2SON-4_1x1mm_P0.65mm; LCSC C30875939
U102: ICE40UL1K-CM36AI; UCBGA-36_2.5x2.5mm_Layout6x6_P0.4mm; LCSC C1519040
U103: TPS7A20L_2V5; Texas_X2SON-4_1x1mm_P0.65mm; LCSC C41487851
U104: TPS7A20L_3V3; Texas_X2SON-4_1x1mm_P0.65mm; LCSC C22445532
U105: W25Q32JV; U-PDFN-8; LCSC C2999380
Y101: 12MHz; Oscillator_SMD_Abracon_ASCO-4Pin_1.6x1.2mm; LCSC SMD1612-4P

Connections:
12MHZ_CLK: R101.1, U102.D2 (IOB_8A_G4)
+1V2_CORE: C103.1, C105.1, U101.1 (OUT), U102.D3 (VCC), U102.D4 (VCCPLL), U104.3 (EN)
+2V5_NVCM: C107.1, C109.1, U102.B4 (VPP2V5), U103.1 (OUT)
+3V3: C101.1, C112.1, C113.1, C115.1, C116.1, R103.1, R104.1, R105.1, R106.1, U102.B3 (VCCIO0), U102.E3 (VCCIO2), U102.E4 (SPI_VCCIO1), U103.3 (EN), U104.1 (OUT), U105.8 (VCC), Y101.1 (Tri-State), Y101.4 (VDD)
+5V: C104.1, C108.1, C110.1, C114.1, U101.3 (EN), U101.4 (IN), U103.4 (IN), U104.4 (IN); also elsewhere on the board
/FPGA/FLASH_~HOLD: R105.2, U105.7 (~HOLD)
/FPGA/FLASH_~WP: R104.2, U105.3 (~WP)
/FPGA/LED: D101.1 (K), U102.A2 (RGB0)
/FPGA/OSC_OUT: R101.2, Y101.3 (OUT)
BARCODE: U102.A5 (BARCODE); also elsewhere on the board
CDONE: D102.2 (A), R106.2, U102.D5 (IOB_11B_CDONE); also elsewhere on the board
FLASH_MISO: U102.E5 (IOB_15B_SI), U105.2 (SDO); also elsewhere on the board
FLASH_MOSI: U102.F6 (IOB_14A_SO), U105.5 (SDI); also elsewhere on the board
FLASH_SCK: U102.E6 (IOB_16A_SCK), U105.6 (SCK); also elsewhere on the board
FLASH_~CS: U102.F5 (IOB_17B_SS), U105.1 (~CS); also elsewhere on the board
GND: C101.2, C103.2, C104.2, C105.2, C107.2, C108.2, C109.2, C110.2, C112.2, C113.2, C114.2, C115.2, C116.2, D102.1 (K), U101.2 (GND), U101.5 (Pad), U102.C3 (GND), U102.C4 (GND), U102.C5 (GND_LED), U103.2 (GND), U103.5 (Pad), U104.2 (GND), U104.5 (Pad), U105.4 (GND), Y101.2 (GND); also elsewhere on the board
IOB_0A: U102.F1 (IOB_0A); also elsewhere on the board
IOB_1B: U102.E1 (IOB_1B); also elsewhere on the board
IOB_3B_G6: U102.F2 (IOB_3B_G6); also elsewhere on the board
IOB_4A: U102.D1 (IOB_4A); also elsewhere on the board
IOB_5B: U102.C1 (IOB_5B); also elsewhere on the board
IOB_6A: U102.E2 (IOB_6A); also elsewhere on the board
IOB_7B_G5: U102.F3 (IOB_7B_G5); also elsewhere on the board
IOB_10A: U102.D6 (IOB_10A); also elsewhere on the board
IOT_18B: U102.B5 (IOT_18B); also elsewhere on the board
IOT_19A: U102.A4 (IOT_19A); also elsewhere on the board
IOT_21A_G1: U102.B6 (IOT_21A_G1); also elsewhere on the board
IOT_22B_G0: U102.C6 (IOT_22B_G0); also elsewhere on the board
IOT_24B: U102.B2 (IOT_24B); also elsewhere on the board
IOT_25A: U102.A3 (IOT_25A); also elsewhere on the board
IOT_27A: U102.C2 (IOT_27A); also elsewhere on the board
IRLED: U102.A6 (IRLED); also elsewhere on the board
unnamed: D101.2 (A), R103.2
RGB1: U102.B1 (RGB1); also elsewhere on the board
RGB2: U102.A1 (RGB2); also elsewhere on the board
~CRESET: U102.F4 (~CRESET); also elsewhere on the board

Notes on the sheet:
If the LED shines, the device has been configured properly
Filtering suggested by the manufacturer
Multiple net names are used to indicate the I/O banks throughout the schematic
FPGA [1]
Keep close to the FPGA pads!
EN_HIGH = 0.9V EN_LOW = 0.3V EN_MAX = 6.5V
No room for larger bulk capacitors
VCCIO0 = 3V3
CDONE is an Open-Drain Output which goes high after the device has been configured successfully
Used for LED driving
The NVCM regulator can be omitted and the VPP2V5 pin can be connected directly to 3V3 in order to save cost. The pin can handle 3.6V. A diode can be used to drop the voltage before by roughly 0.7V
VCCIO1 = 3V3
Part choice may be subject to change in the next revision
See: iCE40 Programming and Configuration app note Section 9.2. SPI PROM Requirements
Chip is active when ~{CRESET} is LOW
IO Supply
FPGA Power Input
Bank 0 I/O
NVCM Supply
Core Supply Voltage
Bank 2 I/O
Open-Drain Outputs
External Oscillator
SPI Flash
Input Bulk

Parts:
D201, D202, D203, D204, D205, D206, D207, D209, D210, D211, D212, D213, D214, D215, D216, D217, D218, D219, D220, D221, D222, D223, D224, D225, D226: TVS; WLL-2-3; LCSC C2939949
D208: TSV; WLL-2-3; LCSC C2939949
J201: Connector_Left; 7-Pin_Casselated_Edge
J202: Connector_Bottom; 7-Pin_Casselated_Edge
J203: Connector_Right; 7-Pin_Casselated_Edge
J205: Connector_Top; 6-Pin_Casselated_Edge

Connections:
+5V: D215.2 (A2), J201.6; also elsewhere on the board
BARCODE: D218.2 (A2), J203.3; also elsewhere on the board
CDONE: D221.2 (A2), J205.5; also elsewhere on the board
FLASH_MISO: D223.2 (A2), J205.2; also elsewhere on the board
FLASH_MOSI: D225.2 (A2), J205.4; also elsewhere on the board
FLASH_SCK: D224.2 (A2), J205.3; also elsewhere on the board
FLASH_~CS: D222.2 (A2), J205.1; also elsewhere on the board
GND: D201.1 (A1), D202.1 (A1), D203.1 (A1), D204.1 (A1), D205.1 (A1), D206.1 (A1), D207.1 (A1), D208.1 (A1), D209.1 (A1), D210.1 (A1), D211.1 (A1), D212.1 (A1), D213.1 (A1), D214.1 (A1), D215.1 (A1), D216.1 (A1), D217.1 (A1), D218.1 (A1), D219.1 (A1), D220.1 (A1), D221.1 (A1), D222.1 (A1), D223.1 (A1), D224.1 (A1), D225.1 (A1), D226.1 (A1), J201.7; also elsewhere on the board
IOB_0A: D210.2 (A2), J202.6; also elsewhere on the board
IOB_1B: D209.2 (A2), J202.7; also elsewhere on the board
IOB_3B_G6: D208.2 (A2), J202.5; also elsewhere on the board
IOB_4A: D214.2 (A2), J201.2; also elsewhere on the board
IOB_5B: D213.2 (A2), J201.3; also elsewhere on the board
IOB_6A: D206.2 (A2), J202.3; also elsewhere on the board
IOB_7B_G5: D207.2 (A2), J202.4; also elsewhere on the board
IOB_10A: D205.2 (A2), J202.2; also elsewhere on the board
IOT_18B: D220.2 (A2), J201.1; also elsewhere on the board
IOT_19A: D217.2 (A2), J203.2; also elsewhere on the board
IOT_21A_G1: D203.2 (A2), J203.7; also elsewhere on the board
IOT_22B_G0: D204.2 (A2), J202.1; also elsewhere on the board
IOT_24B: D202.2 (A2), J203.6; also elsewhere on the board
IOT_25A: D216.2 (A2), J203.1; also elsewhere on the board
IOT_27A: D201.2 (A2), J203.5; also elsewhere on the board
IRLED: D219.2 (A2), J203.4; also elsewhere on the board
RGB1: D212.2 (A2), J201.4; also elsewhere on the board
RGB2: D211.2 (A2), J201.5; also elsewhere on the board
~CRESET: D226.2 (A2), J205.6; also elsewhere on the board

Notes on the sheet:
Connectivity [2]
ESD Protection
Edge Connectors

Board: 6 copper layers, 13.0 x 13.0 mm, 56 parts (0 on the bottom side), 36 nets.

File Hardware/Core_Module/gerber/Core_Module_BOM.csv:

"Designator","Qty","Comment","DNP","Exclude from BOM","Exclude from Board","LCSC","Footprint","Datasheet","Manufacturer"
"C101,C103,C107,C112,C113,C116","6","100n","","","","C668346","Capacitor_SMD:C_0201_0603Metric","https://www.lcsc.com/product-detail/C668346.html","Murata"
"C104,C105,C108,C109,C114,C115","6","1u","","","","C335102","Capacitor_SMD:C_0201_0603Metric","https://www.lcsc.com/product-detail/C335102.html","Murata"
"C110","1","2.2u","","","","C335106","Capacitor_SMD:C_0201_0603Metric","https://www.lcsc.com/product-detail/C335106.html","Murata"
"D101,D102","2","LED","","","","C4153580,C5846955","LED_SMD:LED_0201_0603Metric","https://www.lcsc.com/product-detail/C4153580.html,https://www.lcsc.com/product-detail/C5846955.html","Kingbright"
"D201,D202,D203,D204,D205,D206,D207,D209,D210,D211,D212,D213,D214,D215,D216,D217,D218,D219,D220,D221,D222,D223,D224,D225,D226","25","TVS","","","","C2939949","Custom_VoxLink_Footprints:WLL-2-3","https://www.lcsc.com/product-detail/C2939949.html","Infineon"
"D208","1","TSV","","","","C2939949","Custom_VoxLink_Footprints:WLL-2-3","https://www.lcsc.com/product-detail/C2939949.html","Infineon"
"R101","1","22R","","","","C3009113","Resistor_SMD:R_0201_0603Metric","https://www.lcsc.com/product-detail/C3009113.html","Vishay"
"R103,R106","2","499R","","","","C2094902","Resistor_SMD:R_0201_0603Metric","https://www.lcsc.com/product-detail/C2094902.html","Vishay"
"R104,R105","2","10k","","","","C844303","Resistor_SMD:R_0201_0603Metric","https://www.lcsc.com/product-detail/C844303.html","Vishay"
"U101","1","TPS7A20L_1V2","","","","C30875939","Package_SON:Texas_X2SON-4_1x1mm_P0.65mm","https://www.lcsc.com/product-detail/C30875939.html?s_z=n_C30875939","TI"
"U102","1","ICE40UL1K-CM36AI","","","","C1519040","Package_BGA:UCBGA-36_2.5x2.5mm_Layout6x6_P0.4mm","https://www.lcsc.com/product-detail/C1519040.html?s_z=n_C1519040","Lattice"
"U103","1","TPS7A20L_2V5","","","","C41487851","Package_SON:Texas_X2SON-4_1x1mm_P0.65mm","https://www.lcsc.com/product-detail/C41487851.html?s_z=n_TPS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","TI"
"U104","1","TPS7A20L_3V3","","","","C22445532","Package_SON:Texas_X2SON-4_1x1mm_P0.65mm","https://www.lcsc.com/product-detail/C22445532.html?s_z=n_TPS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","TI"
"U105","1","W25Q32JV","","","","C2999380","Custom_VoxLink_Footprints:U-PDFN-8","https://www.lcsc.com/product-detail/C2999380.html?s_z=n_W25Q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","Winbond"
"Y101","1","12MHz","","","","SMD1612-4P","Oscillator:Oscillator_SMD_Abracon_ASCO-4Pin_1.6x1.2mm","https://www.lcsc.com/product-detail/C2032475.html","Abracon"

## KiCad design Hardware/Core_Module_Intel/Core_Module_Intel.kicad_pcb

Board: 6 copper layers, 13.0 x 13.0 mm, 27 parts (0 on the bottom side), 22 nets, no tracks yet.

Parts:
C104, C105, C108, C109: 1u; C_0402_1005Metric
C110, C111, C112, C113, C116, C117: 100n; C_0402_1005Metric
D101, D102: LED; LED_0201_0603Metric
J201: Connector_Left; 7-Pin_Casselated_Edge
J202: Connector_Bottom; 7-Pin_Casselated_Edge
J203: Connector_Right; 7-Pin_Casselated_Edge
J205: Connector_Top; 6-Pin_Casselated_Edge
R2, R3, R4, R5: 10k; R_0402_1005Metric
R6, R7: 100R; R_0402_1005Metric
R103, R106: 510R; R_0201_0603Metric
U1: 10M02DCV36C8G
U101: TPS7A20L_1V2; Texas_X2SON-4_1x1mm_P0.65mm
U103: TPS7A20L_2V5; Texas_X2SON-4_1x1mm_P0.65mm

Connections:
+1V2_CORE: C105.1, C110.1, C111.1, U1.B1 (VCC), U1.F5 (VCC), U101.1 (OUT)
+2V5: C109.1, C112.1, C113.1, C116.1, C117.1, R2.1, R3.1, R4.1, R5.1, R106.1, U1.A1 (VCCA3), U1.A6 (VCCA2), U1.C4 (VCCIO_1_2_8), U1.D4 (VCCIO_3_5_6), U103.1 (OUT)
+5V: C104.1, C108.1, J201.6, U101.3 (EN), U101.4 (IN), U103.4 (IN)
/IN_CLK_N: J202.5, R6.2, U1.E6 (DIFFOUT_R10n)
/IN_CLK_P: J202.4, R6.1, U1.D6 (DIFFOUT_R10p)
/IN_DATA_N: J201.3, R7.2, U1.C6 (DIFFOUT_R12n)
/IN_DATA_P: J201.2, R7.1, U1.D5 (DIFFOUT_R12p)
/OUT_CLK_N: J202.2, U1.F2 (DIFFOUT_B1n)
/OUT_CLK_P: J202.1, U1.F3 (DIFFOUT_B1p)
/OUT_DATA_N: J202.7, U1.E3 (DIFFOUT_B7n)
/OUT_DATA_P: J202.6, U1.F4 (DIFFOUT_B7p)
GND: C104.2, C105.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C116.2, C117.2, D101.1 (K), D102.1 (K), J201.1, J201.7, J202.3, U1.B3 (GND), U1.F1 (GND), U1.F6 (GND), U101.2 (GND), U101.5 (Pad), U103.2 (GND), U103.5 (Pad)
unnamed: D101.2 (A), R103.2
unnamed: D102.2 (A), R106.2
unnamed: R3.2, U1.A2 (CONFIG_DONE)
unnamed: R2.2, U1.C2 (JTAGEN)
unnamed: R4.2, U1.A4 (NCONFIG)
unnamed: R5.2, U1.B2 (NSTATUS)
TCK: J205.3, U1.D3 (TCK)
TDI: J205.4, U1.C1 (TDI)
TDO: J205.2, U1.D2 (TDO)
TMS: J205.1, U1.C3 (TMS)

## KiCad design Hardware/Controller_Board/Controller_Board.kicad_pcb

Notes on the sheet:
Technical Sheet Only! Please refer to the subsequent sheets for schematic
Root [0]

Parts:
C301: 1u; C_0402_1005Metric
C302, C303: 100n; C_0402_1005Metric
D301: LED; LED_0603_1608Metric
R301: 200R; R_0402_1005Metric
R302: 100R; R_0402_1005Metric
R303, R304, R305, R306: 4.7k; R_0201_0603Metric
R307, R308, R309, R310: 4.7k; R_0402_1005Metric
R311: 22R; R_0402_1005Metric
Re301, Re302: 4.7k; R_0201_0603Metric
SW301: Reset; SW_Push_SPST_NO_Alps_SKRK
TP301: N3; TestPoint_Pad_D1.0mm
TP302: M2; TestPoint_Pad_D1.0mm
TP303: M3; TestPoint_Pad_D1.0mm
TP304: L3; TestPoint_Pad_D1.0mm
TP305: K3; TestPoint_Pad_D1.0mm
U201: XC7A35T-CSG324; Xilinx_CSG324
U301: IS25LP256D; WSON-8-1EP_8.0x6.0mm_P1.27mm_EP4.7x4.6mm
Y301: 12MHz; Oscillator_SMD_Abracon_ASCO-4Pin_1.6x1.2mm

Connections:
12MHZ_CLK: R311.1, U201.C10 (IO_L13N_T2_MRCC_16)
+3V3: C302.1, C303.1, R301.1, R303.1, R304.1, R305.2, R306.1, R307.1, R308.1, R309.1, R310.1, U301.8 (VCC), Y301.1 (Tri-State), Y301.4 (VDD); also elsewhere on the board
/FPGA_Config/FPGA_DONE: R301.2, R302.1, U201.P10 (DONE_0)
/FPGA_Config/FPGA_INIT: R306.2, U201.P7 (INIT_B_0)
/FPGA_Config/FPGA_RST: C301.1, R307.2, SW301.1, U201.P9 (PROGRAM_B_0)
/FPGA_Config/MODE0: R305.1, U201.P12 (M0_0)
/FPGA_Config/MODE1: Re301.1, U201.P13 (M1_0)
/FPGA_Config/MODE2: Re302.1, U201.P11 (M2_0)
/FPGA_Config/NCS_FPGA: R310.2, U201.L13 (IO_L6P_T0_FCS_B_14), U301.1 (NCS)
/FPGA_Config/NHL_FPGA: R308.2, U201.M14 (IO_L2N_T0_D03_14), U301.7 (NHOLD)
/FPGA_Config/NWP_FPGA: R309.2, U201.L14 (IO_L2P_T0_D02_14), U301.3 (NWP)
/FPGA_Config/OSC_OUT: R311.2, Y301.3 (OUT)
/FPGA_Config/SCK_FPGA: U201.E9 (CCLK_0), U201.L16 (IO_L3N_T0_DQS_EMCCLK_14), U301.6 (SCK)
/FPGA_Config/SDI_FPGA: U201.K17 (IO_L1P_T0_D00_MOSI_14), U301.5 (SDI)
/FPGA_Config/SDO_FPGA: U201.K18 (IO_L1N_T0_D01_DIN_14), U301.2 (SDO)
GND: C301.2, C302.2, C303.2, D301.1 (K), Re301.2, Re302.2, SW301.2, U201.J9 (VREFN_0), U201.J10 (VP_0), U201.K9 (VN_0), U201.K10 (VREFP_0), U201.L9 (DXN_0), U201.L10 (DXP_0), U301.4 (GND), U301.9 (GND), Y301.2 (GND); also elsewhere on the board
unnamed: D301.2 (A), R302.2
unnamed: R303.2, U201.P8 (CFGBVS_0)
unnamed: R304.2, U201.L15 (IO_L3P_T0_DQS_PUDC_B_14)
unnamed: TP305.1 (1_1), U201.D9 (IO_L6N_T0_VREF_16)
unnamed: TP303.1 (1_1), U201.B9 (IO_L11N_T1_SRCC_16)
unnamed: TP304.1 (1_1), U201.C9 (IO_L11P_T1_SRCC_16)
unnamed: TP301.1 (1_1), U201.A8 (IO_L12N_T1_MRCC_16)
unnamed: TP302.1 (1_1), U201.B8 (IO_L12P_T1_MRCC_16)
TCK: U201.E10 (TCK_0); also elsewhere on the board
TDI: U201.E11 (TDI_0); also elsewhere on the board
TDO: U201.E13 (TDO_0); also elsewhere on the board
TMS: U201.E12 (TMS_0); also elsewhere on the board

Notes on the sheet:
Thermal diode Connect to GND id not used
Connect to ground for on-chip XADC reference (UG480)
UG470 Datasheet
Maximum power-up time delay for Flash instruction readiness is 10ms. According to the DS181 AMD datasheet, the minimum FPGA Power-On Reset TPOR is also 10ms. By implementing a capacitor on the PROGRAM_B pin of the FPGA, the startup sequence is intentionally delayed to ensure a safe margin where the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
For FLASH config outside bootloader mode
If the LED shines, the device has been configured properly!
FPGA Manual Reset
HIGH to set JTAG to 3.3V/2.5V operation (UG470)
HIGH to disable internal pullups during startup
This configuration makes the FPGA boot from SPI
Capacitor charge time is 4.7ms
Dedicated analog input. Connect to GND if not used (UG480)
FPGA Config [3]
Test Points
Additionally, there is a delay to even start the spi communication after booting the FPGA up, so we're in the clear.
Since we're not using XADC, we tie ADCGND to GND (for VP_0 and VN_0)
FPGA Configuration
External Oscillator
FPGA IOs
Configuration DONE
