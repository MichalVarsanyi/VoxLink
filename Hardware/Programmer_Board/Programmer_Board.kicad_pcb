# Repository MichalVarsanyi/VoxLink (continued)

## KiCad design Hardware/Controller_Board/Controller_Board.kicad_pcb (continued)

Parts:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
R701, R702, R703, R704, R705, R706, R707, R708, R709, R710, R711, R712, R713, R714, R715, R716, R717, R718: 1k; R_0402_1005Metric
U201: XC7A35T-CSG324; Xilinx_CSG324
U701, U702, U703, U710, U711, U712, U716, U717, U718: RJ45; TE_RJ45
U704, U705, U706, U713, U714, U715, U719, U720, U721, U722, U723, U724, U725, U726, U727, U728, U729, U730: TPD4E02B04; USON-10_2.5x1.0mm_P0.5mm

Connections:
+5V: U701.3 (VCC), U702.3 (VCC), U703.3 (VCC), U710.3 (VCC), U711.3 (VCC), U712.3 (VCC), U716.3 (VCC), U717.3 (VCC), U718.3 (VCC); also elsewhere on the board
/Connectivity/P1_CLK_N: U201.R2 (IO_L15N_T2_DQS_34), U701.5 (~CLK), U704.4 (IN), U704.7 (NC)
/Connectivity/P1_CLK_P: U201.P2 (IO_L15P_T2_DQS_34), U701.4 (CLK), U704.5 (IN), U704.6 (NC)
/Connectivity/P1_RX_N: U201.V1 (IO_L7N_T1_34), U701.2 (~RX), U725.1 (IN), U725.10 (NC)
/Connectivity/P1_RX_P: U201.U1 (IO_L7P_T1_34), U701.1 (RX), U725.2 (IN), U725.9 (NC)
/Connectivity/P1_TX_N: U201.N1 (IO_L3N_T0_DQS_34), U701.7 (~TX), U704.1 (IN), U704.10 (NC)
/Connectivity/P1_TX_P: U201.N2 (IO_L3P_T0_DQS_34), U701.8 (TX), U704.2 (IN), U704.9 (NC)
/Connectivity/P2_CLK_N: U201.J18 (IO_L23N_T3_FWE_B_15), U710.5 (~CLK), U713.2 (IN), U713.9 (NC)
/Connectivity/P2_CLK_P: U201.J17 (IO_L23P_T3_FOE_B_15), U710.4 (CLK), U713.1 (IN), U713.10 (NC)
/Connectivity/P2_RX_N: U201.G17 (IO_L18N_T2_A23_15), U710.2 (~RX), U726.5 (IN), U726.6 (NC)
/Connectivity/P2_RX_P: U201.H17 (IO_L18P_T2_A24_15), U710.1 (RX), U726.4 (IN), U726.7 (NC)
/Connectivity/P2_TX_N: U201.M18 (IO_L4N_T0_D05_14), U710.7 (~TX), U713.5 (IN), U713.6 (NC)
/Connectivity/P2_TX_P: U201.L18 (IO_L4P_T0_D04_14), U710.8 (TX), U713.4 (IN), U713.7 (NC)
/Connectivity/P3_CLK_N: U201.T18 (IO_L7N_T1_D10_14), U716.5 (~CLK), U719.2 (IN), U719.9 (NC)
/Connectivity/P3_CLK_P: U201.R18 (IO_L7P_T1_D09_14), U716.4 (CLK), U719.1 (IN), U719.10 (NC)
/Connectivity/P3_RX_N: U201.P18 (IO_L9N_T1_DQS_D13_14), U716.2 (~RX), U722.5 (IN), U722.6 (NC)
/Connectivity/P3_RX_P: U201.N17 (IO_L9P_T1_DQS_14), U716.1 (RX), U722.4 (IN), U722.7 (NC)
/Connectivity/P3_TX_N: U201.U18 (IO_L17N_T2_A13_D29_14), U716.7 (~TX), U719.5 (IN), U719.6 (NC)
/Connectivity/P3_TX_P: U201.U17 (IO_L17P_T2_A14_D30_14), U716.8 (TX), U719.4 (IN), U719.7 (NC)
/Connectivity/P4_CLK_N: U201.U11 (IO_L19N_T3_A09_D25_VREF_14), U702.5 (~CLK), U705.4 (IN), U705.7 (NC)
/Connectivity/P4_CLK_P: U201.T11 (IO_L19P_T3_A10_D26_14), U702.4 (CLK), U705.5 (IN), U705.6 (NC)
/Connectivity/P4_RX_N: U201.V12 (IO_L20N_T3_A07_D23_14), U702.2 (~RX), U727.1 (IN), U727.10 (NC)
/Connectivity/P4_RX_P: U201.U12 (IO_L20P_T3_A08_D24_14), U702.1 (RX), U727.2 (IN), U727.9 (NC)
/Connectivity/P4_TX_N: U201.V9 (IO_L21N_T3_DQS_34), U702.7 (~TX), U705.1 (IN), U705.10 (NC)
/Connectivity/P4_TX_P: U201.U9 (IO_L21P_T3_DQS_34), U702.8 (TX), U705.2 (IN), U705.9 (NC)
/Connectivity/P5_CLK_N: U201.V16 (IO_L16N_T2_A15_D31_14), U711.5 (~CLK), U714.4 (IN), U714.7 (NC)
/Connectivity/P5_CLK_P: U201.V15 (IO_L16P_T2_CSI_B_14), U711.4 (CLK), U714.5 (IN), U714.6 (NC)
/Connectivity/P5_RX_N: U201.V17 (IO_L18N_T2_A11_D27_14), U711.2 (~RX), U728.1 (IN), U728.10 (NC)
/Connectivity/P5_RX_P: U201.U16 (IO_L18P_T2_A12_D28_14), U711.1 (RX), U728.2 (IN), U728.9 (NC)
/Connectivity/P5_TX_N: U201.V14 (IO_L22N_T3_A04_D20_14), U711.7 (~TX), U714.2 (IN), U714.9 (NC)
/Connectivity/P5_TX_P: U201.U14 (IO_L22P_T3_A05_D21_14), U711.8 (TX), U714.1 (IN), U714.10 (NC)
/Connectivity/P6_CLK_N: U201.V4 (IO_L10N_T1_34), U717.5 (~CLK), U720.4 (IN), U720.7 (NC)
/Connectivity/P6_CLK_P: U201.V5 (IO_L10P_T1_34), U717.4 (CLK), U720.5 (IN), U720.6 (NC)
/Connectivity/P6_RX_N: U201.V6 (IO_L20N_T3_34), U717.2 (~RX), U723.1 (IN), U723.10 (NC)
/Connectivity/P6_RX_P: U201.V7 (IO_L20P_T3_34), U717.1 (RX), U723.2 (IN), U723.9 (NC)
/Connectivity/P6_TX_N: U201.V2 (IO_L9N_T1_DQS_34), U717.7 (~TX), U720.1 (IN), U720.10 (NC)
/Connectivity/P6_TX_P: U201.U2 (IO_L9P_T1_DQS_34), U717.8 (TX), U720.2 (IN), U720.9 (NC)
/Connectivity/P7_CLK_N: U201.E1 (IO_L18N_T2_35), U703.5 (~CLK), U706.4 (IN), U706.7 (NC)
/Connectivity/P7_CLK_P: U201.F1 (IO_L18P_T2_35), U703.4 (CLK), U706.5 (IN), U706.6 (NC)
/Connectivity/P7_RX_N: U201.G1 (IO_L17N_T2_35), U703.2 (~RX), U729.1 (IN), U729.10 (NC)
/Connectivity/P7_RX_P: U201.H1 (IO_L17P_T2_35), U703.1 (RX), U729.2 (IN), U729.9 (NC)
/Connectivity/P7_TX_N: U201.C1 (IO_L16N_T2_35), U703.7 (~TX), U706.1 (IN), U706.10 (NC)
/Connectivity/P7_TX_P: U201.C2 (IO_L16P_T2_35), U703.8 (TX), U706.2 (IN), U706.9 (NC)
/Connectivity/P8_CLK_N: U201.K1 (IO_L23N_T3_35), U712.5 (~CLK), U730.4 (IN), U730.7 (NC)
/Connectivity/P8_CLK_P: U201.K2 (IO_L23P_T3_35), U712.4 (CLK), U730.5 (IN), U730.6 (NC)
/Connectivity/P8_RX_N: U201.M2 (IO_L4N_T0_34), U712.2 (~RX), U715.1 (IN), U715.10 (NC)
/Connectivity/P8_RX_P: U201.M3 (IO_L4P_T0_34), U712.1 (RX), U715.2 (IN), U715.9 (NC)
/Connectivity/P8_TX_N: U201.J2 (IO_L22N_T3_35), U712.7 (~TX), U730.1 (IN), U730.10 (NC)
/Connectivity/P8_TX_P: U201.J3 (IO_L22P_T3_35), U712.8 (TX), U730.2 (IN), U730.9 (NC)
/Connectivity/P9_CLK_N: U201.C17 (IO_L20N_T3_A19_15), U718.5 (~CLK), U724.5 (IN), U724.6 (NC)
/Connectivity/P9_CLK_P: U201.C16 (IO_L20P_T3_A20_15), U718.4 (CLK), U724.4 (IN), U724.7 (NC)
/Connectivity/P9_RX_N: U201.A18 (IO_L10N_T1_AD11N_15), U718.2 (~RX), U724.2 (IN), U724.9 (NC)
/Connectivity/P9_RX_P: U201.B18 (IO_L10P_T1_AD11P_15), U718.1 (RX), U724.1 (IN), U724.10 (NC)
/Connectivity/P9_TX_N: U201.D18 (IO_L21N_T3_DQS_A18_15), U718.7 (~TX), U721.1 (IN), U721.10 (NC)
/Connectivity/P9_TX_P: U201.E18 (IO_L21P_T3_DQS_15), U718.8 (TX), U721.2 (IN), U721.9 (NC)
GND: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), U701.6 (GND), U701.10 (LED2), U701.12 (LED4), U701.13 (SHD), U701.14 (SHD), U702.6 (GND), U702.10 (LED2), U702.12 (LED4), U702.13 (SHD), U702.14 (SHD), U703.6 (GND), U703.10 (LED2), U703.12 (LED4), U703.13 (SHD), U703.14 (SHD), U704.3 (GND), U704.8 (NC), U705.3 (GND), U705.8 (NC), U706.3 (GND), U706.8 (NC), U710.6 (GND), U710.10 (LED2), U710.12 (LED4), U710.13 (SHD), U710.14 (SHD), U711.6 (GND), U711.10 (LED2), U711.12 (LED4), U711.13 (SHD), U711.14 (SHD), U712.6 (GND), U712.10 (LED2), U712.12 (LED4), U712.13 (SHD), U712.14 (SHD), U713.3 (GND), U713.8 (NC), U714.3 (GND), U714.8 (NC), U715.3 (GND), U715.8 (NC), U716.6 (GND), U716.10 (LED2), U716.12 (LED4), U716.13 (SHD), U716.14 (SHD), U717.6 (GND), U717.10 (LED2), U717.12 (LED4), U717.13 (SHD), U717.14 (SHD), U718.6 (GND), U718.10 (LED2), U718.12 (LED4), U718.13 (SHD), U718.14 (SHD), U719.3 (GND), U719.8 (NC), U720.3 (GND), U720.8 (NC), U721.3 (GND), U721.8 (NC), U722.3 (GND), U722.8 (NC), U723.3 (GND), U723.8 (NC), U724.3 (GND), U724.8 (NC), U725.3 (GND), U725.8 (NC), U726.3 (GND), U726.8 (NC), U727.3 (GND), U727.8 (NC), U728.3 (GND), U728.8 (NC), U729.3 (GND), U729.8 (NC), U730.3 (GND), U730.8 (NC); also elsewhere on the board
unnamed: R701.2, U701.9 (LED1)
unnamed: R704.2, U701.11 (LED3)
unnamed: R702.2, U702.9 (LED1)
unnamed: R705.2, U702.11 (LED3)
unnamed: R703.2, U703.9 (LED1)
unnamed: R706.2, U703.11 (LED3)
unnamed: R707.2, U710.9 (LED1)
unnamed: R710.2, U710.11 (LED3)
unnamed: R708.2, U711.9 (LED1)
unnamed: R711.2, U711.11 (LED3)
unnamed: R709.2, U712.9 (LED1)
unnamed: R712.2, U712.11 (LED3)
unnamed: R713.2, U716.9 (LED1)
unnamed: R716.2, U716.11 (LED3)
unnamed: R714.2, U717.9 (LED1)
unnamed: R717.2, U717.11 (LED3)
unnamed: R715.2, U718.9 (LED1)
unnamed: R718.2, U718.11 (LED3)
P1_L1: R701.1, U201.U3 (IO_L8N_T1_34)
P1_L2: R704.1, U201.U4 (IO_L8P_T1_34)
P2_L1: R707.1, U201.R17 (IO_L12N_T1_MRCC_14)
P2_L2: R710.1, U201.P17 (IO_L12P_T1_MRCC_14)
P3_L1: R713.1, U201.R15 (IO_L13N_T2_MRCC_14)
P3_L2: R716.1, U201.R16 (IO_L15P_T2_DQS_RDWR_B_14)
P4_L1: R702.1, U201.T9 (IO_L24P_T3_A01_D17_14)
P4_L2: R705.1, U201.T10 (IO_L24N_T3_A00_D16_14)
P5_L1: R708.1, U201.T14 (IO_L14P_T2_SRCC_14)
P5_L2: R711.1, U201.T15 (IO_L14N_T2_SRCC_14)
P6_L1: R714.1, U201.U6 (IO_L22N_T3_34)
P6_L2: R717.1, U201.U7 (IO_L22P_T3_34)
P7_L1: R703.1, U201.L3 (IO_L2N_T0_34)
P7_L2: R706.1, U201.K3 (IO_L2P_T0_34)
P8_L1: R709.1, U201.P4 (IO_L14P_T2_SRCC_34)
P8_L2: R712.1, U201.P5 (IO_L13N_T2_MRCC_34)
P9_L1: R715.1, U201.A16 (IO_L8N_T1_AD10N_15)
P9_L2: R718.1, U201.A15 (IO_L8P_T1_AD10P_15)
SERIAL_CLK: U201.E3 (IO_L12P_T1_MRCC_35); also elsewhere on the board
SERIAL_D1: U201.B1 (IO_L9P_T1_DQS_AD7P_35); also elsewhere on the board
SERIAL_D2: U201.A1 (IO_L9N_T1_DQS_AD7N_35); also elsewhere on the board
SERIAL_D3: U201.B2 (IO_L10N_T1_AD15N_35); also elsewhere on the board
SERIAL_D4: U201.B3 (IO_L10P_T1_AD15P_35); also elsewhere on the board
SERIAL_D5: U201.A3 (IO_L8N_T1_AD14N_35); also elsewhere on the board
SERIAL_D6: U201.B4 (IO_L7N_T1_AD6N_35); also elsewhere on the board
SERIAL_D7: U201.A4 (IO_L8P_T1_AD14P_35); also elsewhere on the board
SERIAL_D8: U201.A5 (IO_L3N_T0_DQS_AD5N_35); also elsewhere on the board
SERIAL_OE#: U201.B7 (IO_L2P_T0_AD12P_35); also elsewhere on the board
SERIAL_PWR#: U201.A6 (IO_L3P_T0_DQS_AD5P_35); also elsewhere on the board
SERIAL_RD#: U201.E2 (IO_L14P_T2_SRCC_35); also elsewhere on the board
SERIAL_RXF#: U201.D3 (IO_L12N_T1_MRCC_35); also elsewhere on the board
SERIAL_SIWU#: U201.C4 (IO_L7P_T1_AD6P_35); also elsewhere on the board
SERIAL_TXE#: U201.D2 (IO_L14N_T2_SRCC_35); also elsewhere on the board
SERIAL_WR#: U201.D5 (IO_L11P_T1_SRCC_35); also elsewhere on the board

Notes on the sheet:
Connectivity [7]
Ethernet Connectors
FPGA IOs

Parts:
C401: 10u; C_0805_2012Metric
C402, C403, C404, C405, C407, C408, C410, C411, C413, C414: 100n; C_0402_1005Metric
C409, C412: 10u; C_0603_1608Metric
C415, C416: 10p; C_0402_1005Metric
FB401, FB402: 600R; L_0402_1005Metric
R401: 1k; R_0402_1005Metric
R402, R403, R404, R405: 12k; R_0402_1005Metric
R406: 2k2; R_0402_1005Metric
R407: 22R; R_0402_1005Metric
U401: FT232H; QFN-48-1EP_8x8mm_P0.5mm_EP6.2x6.2mm
U402: 93LC56B; TDFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.4mm
Y3: 12MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C401.1, C402.1, C403.1, C404.1, C405.1, C414.1, FB401.2, FB402.2, R401.1, R403.2, R404.2, R405.2, U401.12 (VCCIO), U401.24 (VCCIO), U401.39 (VCCD), U401.40 (VREGIN), U401.46 (VCCIO), U402.6 (ORG), U402.8 (VCC); also elsewhere on the board
+3V3_VPHY_JTAG: C409.1, C410.1, FB401.1, U401.3 (VPHY)
+3V3_VPLL_JTAG: C412.1, C413.1, FB402.1, U401.8 (VPLL)
/JTAG/EECLK: R405.1, U401.44 (EECLK), U402.2 (CLK)
/JTAG/EECS: R404.1, U401.45 (EECS), U402.1 (CS)
/JTAG/EEDATA: R406.2, U401.43 (EEDATA), U402.3 (DI)
/JTAG/OSC_IN: C415.1, U401.1 (XCSI), Y3.1
/JTAG/OSC_OUT: R407.1, U401.2 (XCSO)
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, R402.1, U401.4 (AGND), U401.9 (AGND), U401.10 (GND), U401.11 (GND), U401.22 (GND), U401.23 (GND), U401.35 (GND), U401.36 (GND), U401.41 (AGND), U401.42 (TEST), U401.47 (GND), U401.48 (GND), U401.49 (EP), U402.5 (VSS), U402.9 (EP), Y3.2 (G), Y3.4 (G); also elsewhere on the board
JTAG_D+: U401.7 (DP); also elsewhere on the board
JTAG_D-: U401.6 (DM); also elsewhere on the board
unnamed: C416.1, R407.2, Y3.3
unnamed: R402.2, U401.5 (REF)
unnamed: C408.1, U401.37 (VCCA)
unnamed: C407.1, U401.38 (VCCCORE)
unnamed: C411.1, R401.2, U401.34 (~RESET)
unnamed: R403.1, R406.1, U402.4 (DO)
TCK: U401.13 (ADBUS0); also elsewhere on the board
TDI: U401.14 (ADBUS1); also elsewhere on the board
TDO: U401.15 (ADBUS2); also elsewhere on the board
TMS: U401.16 (ADBUS3); also elsewhere on the board

Notes on the sheet:
Ferrite beads must be rated at least for 600mA
JTAG [4]
(10pF Load Capacitance - 5pF Stray Capacitance) * 2 = 10pF Load Capacitors
VREGIN = 5V -> VCCD = 3.3V OUTPUT VREGIN = 3.3V -> VCCD = 3.3V INPUT
FTDI USB-to-JTAG
Filtering
Crystal

Board: 6 copper layers, 85.0 x 85.0 mm, 262 parts (120 on the bottom side), 200 nets.

## Code that names these connections

File Firmware/Vivado/Source/Constraints/VoxLink_Controller.xdc (part):

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#  BANK 14
###################################################################

# set_property PACKAGE_PIN L18 [get_ports P8_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_TX_P]
# set_property PACKAGE_PIN M18 [get_ports P8_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_TX_N]

# set_property PACKAGE_PIN R18 [get_ports P7_CLK_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_CLK_P]
# set_property PACKAGE_PIN T18 [get_ports P7_CLK_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_CLK_N]

# set_property PACKAGE_PIN N17 [get_ports P7_RX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_RX_P]
# set_property PACKAGE_PIN P18 [get_ports P7_RX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_RX_N]

# set_property PACKAGE_PIN V15 [get_ports P6_CLK_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_CLK_P]
# set_property PACKAGE_PIN V16 [get_ports P6_CLK_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_CLK_N]

# set_property PACKAGE_PIN U17 [get_ports P7_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_TX_P]
# set_property PACKAGE_PIN U18 [get_ports P7_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_TX_N]

# set_property PACKAGE_PIN U16 [get_ports P6_RX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_RX_P]
# set_property PACKAGE_PIN V17 [get_ports P6_RX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_RX_N]

# set_property PACKAGE_PIN T11 [get_ports P5_CLK_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_CLK_P]
# set_property PACKAGE_PIN U11 [get_ports P5_CLK_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_CLK_N]

# set_property PACKAGE_PIN U12 [get_ports P5_RX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_RX_P]
# set_property PACKAGE_PIN V12 [get_ports P5_RX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_RX_N]

# set_property PACKAGE_PIN U14 [get_ports P6_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_TX_P]
# set_property PACKAGE_PIN V14 [get_ports P6_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_TX_N]

# LED Pins (Bank 14)
# set_property PACKAGE_PIN R17 [get_ports P8_L1]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_L1]
# set_property PACKAGE_PIN P17 [get_ports P8_L2]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_L2]

# set_property PACKAGE_PIN R15 [get_ports P7_L1]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_L1]
# set_property PACKAGE_PIN R16 [get_ports P7_L2]
# set_property IOSTANDARD LVCMOS33 [get_ports P7_L2]

# set_property PACKAGE_PIN T9 [get_ports P5_L1]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_L1]
# set_property PACKAGE_PIN T10 [get_ports P5_L2]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_L2]

# set_property PACKAGE_PIN T14 [get_ports P6_L1]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_L1]
# set_property PACKAGE_PIN T15 [get_ports P6_L2]
# set_property IOSTANDARD LVCMOS33 [get_ports P6_L2]

# !!! WARNING ALL ETHERNET PINS ARE REFERENCED TO BOARD SILKSCREEN, NOT THE SCHEMATIC NAMING !!!
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#  BANK 15
###################################################################

# set_property PACKAGE_PIN B18 [get_ports P9_RX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_RX_P]
# set_property PACKAGE_PIN A18 [get_ports P9_RX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_RX_N]

# set_property PACKAGE_PIN H17 [get_ports P8_RX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_RX_P]
# set_property PACKAGE_PIN G17 [get_ports P8_RX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_RX_N]

# set_property PACKAGE_PIN C16 [get_ports P9_CLK_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_CLK_P]
# set_property PACKAGE_PIN C17 [get_ports P9_CLK_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_CLK_N]

# set_property PACKAGE_PIN E18 [get_ports P9_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_TX_P]
# set_property PACKAGE_PIN D18 [get_ports P9_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_TX_N]

# set_property PACKAGE_PIN J17 [get_ports P8_CLK_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_CLK_P]
# set_property PACKAGE_PIN J18 [get_ports P8_CLK_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P8_CLK_N]

# LED Pins (Bank 15)
# set_property PACKAGE_PIN A16 [get_ports P9_L1]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_L1]
# set_property PACKAGE_PIN A15 [get_ports P9_L2]
# set_property IOSTANDARD LVCMOS33 [get_ports P9_L2]

# !!! WARNING ALL ETHERNET PINS ARE REFERENCED TO BOARD SILKSCREEN, NOT THE SCHEMATIC NAMING !!!
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#  BANK 34
###################################################################

# set_property PACKAGE_PIN N2 [get_ports P3_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P3_TX_P]
# set_property PACKAGE_PIN N1 [get_ports P3_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P3_TX_N]
# set_property PULLDOWN TRUE [get_ports P3_TX_P]
# set_property PULLDOWN TRUE [get_ports P3_TX_N]

set_property PACKAGE_PIN U1 [get_ports P3_RX_P]
set_property IOSTANDARD LVCMOS33 [get_ports P3_RX_P]
set_property SLEW SLOW [get_ports P3_RX_P]
set_property DRIVE 4 [get_ports P3_RX_P]
set_property PACKAGE_PIN V1 [get_ports P3_RX_N]
set_property IOSTANDARD LVCMOS33 [get_ports P3_RX_N]
set_property SLEW SLOW [get_ports P3_RX_N]
set_property DRIVE 4 [get_ports P3_RX_N]

set_property PACKAGE_PIN P2 [get_ports P3_CLK_P]
set_property IOSTANDARD LVCMOS33 [get_ports P3_CLK_P]
set_property SLEW SLOW [get_ports P3_CLK_P]
set_property DRIVE 4 [get_ports P3_CLK_P]
set_property PACKAGE_PIN R2 [get_ports P3_CLK_N]
set_property IOSTANDARD LVCMOS33 [get_ports P3_CLK_N]
set_property SLEW SLOW [get_ports P3_CLK_N]
set_property DRIVE 4 [get_ports P3_CLK_N]

# set_property PACKAGE_PIN U9 [get_ports P5_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_TX_P]
# set_property PACKAGE_PIN V9 [get_ports P5_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P5_TX_N]

# set_property PACKAGE_PIN U2 [get_ports P4_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_TX_P]
# set_property PACKAGE_PIN V2 [get_ports P4_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_TX_N]

# set_property PACKAGE_PIN V7 [get_ports P4_RX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_RX_P]
# set_property PACKAGE_PIN V6 [get_ports P4_RX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_RX_N]

# set_property PACKAGE_PIN V5 [get_ports P4_CLK_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_CLK_P]
# set_property PACKAGE_PIN V4 [get_ports P4_CLK_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_CLK_N]

# LED Pins (Bank 34)
set_property PACKAGE_PIN U3 [get_ports P3_L1]
set_property IOSTANDARD LVCMOS33 [get_ports P3_L1]
set_property PACKAGE_PIN U4 [get_ports P3_L2]
set_property IOSTANDARD LVCMOS33 [get_ports P3_L2]

# set_property PACKAGE_PIN U6 [get_ports P4_L1]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_L1]
# set_property PACKAGE_PIN U7 [get_ports P4_L2]
# set_property IOSTANDARD LVCMOS33 [get_ports P4_L2]

# set_property PACKAGE_PIN L3 [get_ports P1_L1]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_L1]
# set_property PACKAGE_PIN K3 [get_ports P1_L2]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_L2]

set_property PACKAGE_PIN P4 [get_ports P2_L1]
set_property IOSTANDARD LVCMOS33 [get_ports P2_L1]
set_property PACKAGE_PIN P5 [get_ports P2_L2]
set_property IOSTANDARD LVCMOS33 [get_ports P2_L2]

# !!! WARNING ALL ETHERNET PINS ARE REFERENCED TO BOARD SILKSCREEN, NOT THE SCHEMATIC NAMING !!!
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# set_property IOSTANDARD LVCMOS33 [get_ports {SERIAL_D[4]}]
# set_property PACKAGE_PIN B2 [get_ports {SERIAL_D[3]}]
# set_property IOSTANDARD LVCMOS33 [get_ports {SERIAL_D[3]}]
set_property PACKAGE_PIN A1 [get_ports SERIAL_D2]
set_property IOSTANDARD LVCMOS33 [get_ports SERIAL_D2]
set_property PACKAGE_PIN B1 [get_ports SERIAL_D1]
set_property IOSTANDARD LVCMOS33 [get_ports SERIAL_D1]

# set_property PACKAGE_PIN E3 [get_ports SERIAL_CLK]
# set_property IOSTANDARD LVCMOS33 [get_ports SERIAL_CLK]

# set_property PACKAGE_PIN C2 [get_ports P1_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_TX_P]
# set_property PACKAGE_PIN C1 [get_ports P1_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_TX_N]

# set_property PACKAGE_PIN H1 [get_ports P1_RX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_RX_P]
# set_property PACKAGE_PIN G1 [get_ports P1_RX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_RX_N]

# set_property PACKAGE_PIN F1 [get_ports P1_CLK_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_CLK_P]
# set_property PACKAGE_PIN E1 [get_ports P1_CLK_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P1_CLK_N]

set_property PACKAGE_PIN J4 [get_ports P2_RX_P]
set_property IOSTANDARD LVCMOS33 [get_ports P2_RX_P]
set_property PACKAGE_PIN H4 [get_ports P2_RX_N]
set_property IOSTANDARD LVCMOS33 [get_ports P2_RX_N]

# set_property PACKAGE_PIN J3 [get_ports P2_TX_P]
# set_property IOSTANDARD LVCMOS33 [get_ports P2_TX_P]
# set_property PACKAGE_PIN J2 [get_ports P2_TX_N]
# set_property IOSTANDARD LVCMOS33 [get_ports P2_TX_N]

set_property PACKAGE_PIN K2 [get_ports P2_CLK_P]
set_property IOSTANDARD LVCMOS33 [get_ports P2_CLK_P]
set_property PACKAGE_PIN K1 [get_ports P2_CLK_N]
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
File Firmware/Lattice/Projects/VoxLink_Protocol/Reference_Code/VOX.pcf:

# ##############################################################################

# iCEcube PCF

# Version:            2020.12.27943

# File Generated:     Dec 26 2025 18:03:53

# Family & Device:    iCE40UL1K

# Package:            CM36A

# ##############################################################################

# General
set_io clk          C2

# SPI Flash
set_io flash_mosi   F6
set_io flash_miso   E5
set_io flash_sck    E6
set_io flash_cs_n   F5

# LED
set_io led_io       A2
set_io led_rx       B1
set_io led_tx       A1

# Sensor
set_io bno_sda      D6
set_io bno_scl      C6
set_io bno_rst_n    B6

# VoxLink
set_io vox_clk_p    E2
set_io vox_clk_n    F3

set_io vox_rx_p     F1
set_io vox_rx_n     E1

set_io vox_tx_p     D1
set_io vox_tx_n     C1
