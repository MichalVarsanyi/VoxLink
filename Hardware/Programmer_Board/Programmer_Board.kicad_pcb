# Repository MichalVarsanyi/VoxLink (continued)

## KiCad design Hardware/Controller_Board/Controller_Board.kicad_pcb (continued)

Parts:
C501: 10u; C_0805_2012Metric
C502, C503, C504, C505, C507, C508, C510, C511, C513, C514: 100n; C_0402_1005Metric
C509, C512: 10u; C_0603_1608Metric
C515, C516: 10p; C_0402_1005Metric
FB501, FB502: 600R; L_0402_1005Metric
R501: 1k; R_0402_1005Metric
R502, R503, R504, R505: 12k; R_0402_1005Metric
R506: 2k2; R_0402_1005Metric
R507: 22R; R_0402_1005Metric
U501: FT232H; QFN-48-1EP_8x8mm_P0.5mm_EP6.2x6.2mm
U502: 93LC56B; TDFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.4mm
Y2: 12MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C501.1, C502.1, C503.1, C504.1, C505.1, C514.1, FB501.2, FB502.2, R501.1, R503.2, R504.2, R505.2, U501.12 (VCCIO), U501.24 (VCCIO), U501.39 (VCCD), U501.40 (VREGIN), U501.46 (VCCIO), U502.6 (ORG), U502.8 (VCC); also elsewhere on the board
+3V3_VPHY_SER: C509.1, C510.1, FB501.1, U501.3 (VPHY)
+3V3_VPLL_SER: C512.1, C513.1, FB502.1, U501.8 (VPLL)
/Serial/EECLK: R505.1, U501.44 (EECLK), U502.2 (CLK)
/Serial/EECS: R504.1, U501.45 (EECS), U502.1 (CS)
/Serial/EEDATA: R506.2, U501.43 (EEDATA), U502.3 (DI)
/Serial/OSC_IN: C515.1, U501.1 (XCSI), Y2.1
/Serial/OSC_OUT: R507.1, U501.2 (XCSO)
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, R502.1, U501.4 (AGND), U501.9 (AGND), U501.10 (GND), U501.11 (GND), U501.22 (GND), U501.23 (GND), U501.35 (GND), U501.36 (GND), U501.41 (AGND), U501.42 (TEST), U501.47 (GND), U501.48 (GND), U501.49 (EP), U502.5 (VSS), U502.9 (EP), Y2.2 (G), Y2.4 (G); also elsewhere on the board
unnamed: C516.1, R507.2, Y2.3
unnamed: R502.2, U501.5 (REF)
unnamed: C508.1, U501.37 (VCCA)
unnamed: C507.1, U501.38 (VCCCORE)
unnamed: C511.1, R501.2, U501.34 (~RESET)
unnamed: R503.1, R506.1, U502.4 (DO)
SERIAL_CLK: U501.29 (ACBUS5); also elsewhere on the board
SERIAL_D1: U501.13 (ADBUS0); also elsewhere on the board
SERIAL_D2: U501.14 (ADBUS1); also elsewhere on the board
SERIAL_D3: U501.15 (ADBUS2); also elsewhere on the board
SERIAL_D4: U501.16 (ADBUS3); also elsewhere on the board
SERIAL_D5: U501.17 (ADBUS4); also elsewhere on the board
SERIAL_D6: U501.18 (ADBUS5); also elsewhere on the board
SERIAL_D7: U501.19 (ADBUS6); also elsewhere on the board
SERIAL_D8: U501.20 (ADBUS7); also elsewhere on the board
SERIAL_D+: U501.7 (DP); also elsewhere on the board
SERIAL_D-: U501.6 (DM); also elsewhere on the board
SERIAL_OE#: U501.30 (ACBUS6); also elsewhere on the board
SERIAL_PWR#: U501.31 (ACBUS7); also elsewhere on the board
SERIAL_RD#: U501.26 (ACBUS2); also elsewhere on the board
SERIAL_RXF#: U501.21 (ACBUS0); also elsewhere on the board
SERIAL_SIWU#: U501.28 (ACBUS4); also elsewhere on the board
SERIAL_TXE#: U501.25 (ACBUS1); also elsewhere on the board
SERIAL_WR#: U501.27 (ACBUS3); also elsewhere on the board

Notes on the sheet:
Ferrite beads must be rated at least for 600mA
Serial [5]
(10pF Load Capacitance - 5pF Stray Capacitance) * 2 = 10pF Load Capacitors
Crystal
FTDI USB-to-UART/SYNC FIFO
Filtering

Parts:
C101, C112, C115: 10u; C_0805_2012Metric
C102, C108, C113, C116: 22u; C_1210_3225Metric
C103, C109, C114, C117: 100u; CP_Elec_5x5.9
C104, C105: 10u; C_1210_3225Metric
C106, C107: 100n; C_0805_2012Metric
C110: 2.2p; C_0402_1005Metric
C111: 10n; C_0402_1005Metric
D101: TVS/Zener; D_0603_1608Metric; not fitted
D102: LED; LED_0603_1608Metric
D103: TVS; D_0402_1005Metric
L101: 2u2; L_Coilcraft_XAL6030-XXX
Q101: DMN2400UFB-7; Diodes_DFN1006-3
R101, R108, R112: 499k; R_0402_1005Metric
R102: 12.5k; R_0402_1005Metric
R103, R110, R114: 50k; R_0402_1005Metric
R104: 1Meg; R_0402_1005Metric
R105: 1R; R_0603_1608Metric
R106: 243k; R_0402_1005Metric
R107: 41.2k; R_0402_1005Metric
R109: 62.5k; R_0402_1005Metric
R111: 280R; R_0402_1005Metric
R113: 156.3k; R_0402_1005Metric
U101, U104, U105: TPS82084; Texas_SIL0008C_MicroSiP-8-1EP_2.8x3mm_P0.65mm_EP1.1x1.9mm
U102: LT8645S; LQFN-32-6EP_6x4mm_P0.5mm_EP1.355x1.125mm
U103: TDS5311P; DFN-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
U106: XT30; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal

Connections:
+1V0: C102.1, C103.1, R102.1, U101.8 (VOUT); also elsewhere on the board
+1V8: C113.1, C114.1, R109.1, U104.8 (VOUT); also elsewhere on the board
+3V3: C116.1, C117.1, R113.1, U105.8 (VOUT); also elsewhere on the board
+5V: C101.1, C108.1, C109.1, C110.1, C112.1, C115.1, L101.2, R101.1, R104.1, R108.1, R111.1, R112.1, U101.1 (EN), U101.3 (VIN), U101.4 (VIN), U102.1 (BIAS), U104.3 (VIN), U104.4 (VIN), U105.3 (VIN), U105.4 (VIN); also elsewhere on the board
/Power/FB_1V0: R102.2, R103.1, U101.7 (FB)
/Power/FB_1V8: R109.2, R110.1, U104.7 (FB)
/Power/FB_3V3: R113.2, R114.1, U105.7 (FB)
/Power/FB_5V0: C110.2, R104.2, R106.1, U102.32 (FB)
/Power/PG_1V0: R101.2, U101.2 (PG), U104.1 (EN)
/Power/PG_1V8: R108.2, U104.2 (PG), U105.1 (EN)
/Power/PG_3V3: Q101.1 (G), R112.2, U105.2 (PG)
/Power/SW_5V0: L101.1, U102.12 (SW), U102.13 (SW), U102.14 (SW), U102.15 (SW), U102.16 (SW)
/Power/TR/SS: C111.1, U102.29 (TR/SS)
GND: C101.2, C102.2, C103.2, C105.2, C106.2, C107.2, C108.2, C109.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, D101.2 (A), D103.1 (A1), Q101.2 (S), R103.2, R105.2, R106.2, R107.2, R110.2, R114.2, U101.5 (GND), U101.6 (GND), U101.9 (GND), U102.8 (GND), U102.9 (GND), U102.10 (GND), U102.17 (GND), U102.18 (GND), U102.19 (GND), U102.33 (GND), U102.34 (GND), U102.35 (GND), U102.36 (GND), U102.37 (GND), U102.38 (GND), U102.39 (GND), U102.40 (GND), U102.41 (GND), U102.42 (GND), U103.4 (GND), U103.5 (GND), U103.6 (GND), U103.7 (GND), U104.5 (GND), U104.6 (GND), U104.9 (GND), U105.5 (GND), U105.6 (GND), U105.9 (GND), U106.1 (GND); also elsewhere on the board
unnamed: C104.2, R105.1
unnamed: D102.2 (A), R111.2
unnamed: D102.1 (K), Q101.3 (D)
unnamed: R107.1, U102.26 (RT)
VIN: C104.1, C105.1, C106.1, C107.1, D101.1 (K), D103.2 (A2), U102.4 (VIN), U102.5 (VIN), U102.6 (VIN), U102.21 (VIN), U102.22 (VIN), U102.23 (VIN), U102.25 (EN/UV), U103.1 (VIN), U103.2 (VIN), U103.3 (VIN), U106.2 (VIN)

Notes on the sheet:
5ms soft-start
Power [1]
MAX VIN is 48V!
10mA through the LED
IO Bank Supply
Power Rail Supply
AUX Cupply
PG Indicator
Input Connector
Core Cupply

Parts:
C601: 10u; C_0805_2012Metric
C602, C603, C604, C605, C606, C607, C608, C610, C612: 100n; C_0402_1005Metric
C609, C611: 10n; C_0402_1005Metric
C613, C614: 10p; C_0402_1005Metric
D601: Schottky; D_SOD-323F
D602, D604: TVS; D_0402_1005Metric
D603: LED; LED_0603_1608Metric
J601: USB-C; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R601, R604: 1k; R_0402_1005Metric
R602, R603: 5k1; R_0402_1005Metric
R605: 12k; R_0402_1005Metric
R606, R607, R608, R609, R610, R612: 100k; R_0402_1005Metric
R611: 22R; R_0402_1005Metric
U601: ESD122; X2SON-3
U602: USB2512B; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm
Y1: 24MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C601.1, C602.1, C603.1, C604.1, C605.1, C606.1, C607.1, R604.1, R606.2, U602.5 (VDDA33), U602.10 (VDDA33), U602.15 (VDD33), U602.23 (VDD33), U602.29 (VDDA33), U602.36 (VDDA33); also elsewhere on the board
+5V: D601.1 (K); also elsewhere on the board
/USB/OSC_IN: C613.1, U602.33 (XTALIN), Y1.1
/USB/OSC_OUT: R611.1, U602.32 (XTALOUT)
GND: C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C611.2, C612.2, C613.2, C614.2, D602.1 (A1), D603.1 (K), D604.1 (A1), J601.A1 (GND), J601.A12 (GND), J601.B1 (GND), J601.B12 (GND), R602.1, R603.1, R605.1, R607.1, R608.1, R609.1, R612.1, U601.1 (G), U602.11 (TEST), U602.37 (EP), Y1.2 (G), Y1.4 (G); also elsewhere on the board
JTAG_D+: U602.4 (USBDP_D2+); also elsewhere on the board
JTAG_D-: U602.3 (USBDP_D2-); also elsewhere on the board
unnamed: C614.1, R611.2, Y1.3
unnamed: D603.2 (A), R601.1
unnamed: J601.A5 (CC1), R602.2
unnamed: J601.B5 (CC2), R603.2
unnamed: R607.2, U602.24 (CFG_SEL0)
unnamed: R608.2, U602.25 (CFG_SEL1)
unnamed: C611.1, C612.1, U602.14 (CRFILT)
unnamed: R609.2, U602.28 (NON_REM0)
unnamed: R606.1, U602.22 (NON_REM1)
unnamed: C608.1, R604.2, U602.26 (NRESET)
unnamed: C609.1, C610.1, U602.34 (PLLFILT)
unnamed: R605.2, U602.35 (RBIAS)
unnamed: R610.1, R612.2, U602.27 (VBUS_DET)
SERIAL_D+: U602.2 (USBDP_D1+); also elsewhere on the board
SERIAL_D-: U602.1 (USBDP_D1-); also elsewhere on the board
USB_UP_D+: J601.A6 (D+), J601.B6 (D+), U601.3 (2), U602.31 (USBUP_D+)
USB_UP_D-: J601.A7 (D-), J601.B7 (D-), U601.2 (1), U602.30 (USBUP_D-)
VBUS: D601.2 (A), D602.2 (A2), D604.2 (A2), J601.A4 (VBUS), J601.A9 (VBUS), J601.B4 (VBUS), J601.B9 (VBUS), R601.2, R610.2

Notes on the sheet:
USB [6]
NON_REM[1:0] = 10 : ports 1 and 2 are non-removable
(10pF Load Capacitance - 5pF Stray Capacitance) * 2 = 10pF Load Capacitors
OCS have internal pullup resistors Since we have non-removable devices we won't check the over-current
Crystal
USB 2.0 Connector
USB 2.0 Hub

Parts:
C201, C203, C204, C207, C208, C209, C210, C211, C212, C213, C214, C215, C216, C217, C218, C220, C221, C222, C223, C224, C225, C226, C227, C229, C230, C231, C232, C233, C235, C238, C239, C240, C241, C242, C243, C244, C245, C246, C247, C250, C251, C252, C253, C254, C255, C256, C257: 100n; C_0201_0603Metric
C205, C206, C219, C234, C237, C248, C249, C258: 10u; C_0603_1608Metric
C236: 10u; C_0805_2012Metric
FB201: 600R/100MHz; L_0201_0603Metric
U201: XC7A35T-CSG324; Xilinx_CSG324

Connections:
+1V0: C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, C220.1, C221.1, C222.1, C223.1, C224.1, C225.1, C226.1, C227.1, C249.1, C250.1, C251.1, U201.F8 (VCCINT), U201.F10 (VCCBRAM), U201.G7 (VCCINT), U201.G9 (VCCINT), U201.G11 (VCCBRAM), U201.H8 (VCCINT), U201.J7 (VCCINT), U201.J11 (VCCINT), U201.K8 (VCCINT), U201.L7 (VCCINT), U201.L11 (VCCINT), U201.M8 (VCCINT), U201.M10 (VCCINT), U201.N7 (VCCINT), U201.N9 (VCCINT), U201.N11 (VCCINT); also elsewhere on the board
+1V8: C237.1, C238.1, C239.1, C240.1, C241.1, FB201.1, U201.E8 (VCCBATT_0), U201.F12 (VCCAUX), U201.H12 (VCCAUX), U201.K12 (VCCAUX), U201.M12 (VCCAUX); also elsewhere on the board
+3V3: C203.1, C204.1, C205.1, C213.1, C214.1, C215.1, C216.1, C217.1, C218.1, C219.1, C229.1, C230.1, C231.1, C232.1, C233.1, C234.1, C235.1, C236.1, C242.1, C243.1, C244.1, C245.1, C246.1, C247.1, C248.1, C252.1, C253.1, C254.1, C255.1, C256.1, C257.1, C258.1, U201.A7 (VCCO_35), U201.A17 (VCCO_15), U201.B10 (VCCO_16), U201.C3 (VCCO_35), U201.C13 (VCCO_15), U201.D6 (VCCO_35), U201.D16 (VCCO_15), U201.F2 (VCCO_35), U201.G5 (VCCO_35), U201.G15 (VCCO_15), U201.H18 (VCCO_15), U201.J1 (VCCO_35), U201.K4 (VCCO_34), U201.K14 (VCCO_15), U201.L17 (VCCO_14), U201.N3 (VCCO_34), U201.N13 (VCCO_14), U201.P6 (VCCO_34), U201.P16 (VCCO_14), U201.R9 (VCCO_0), U201.T2 (VCCO_34), U201.T12 (VCCO_14), U201.U5 (VCCO_34), U201.U15 (VCCO_14), U201.V8 (VCCO_34), U201.V18 (VCCO_14); also elsewhere on the board
GND: C201.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, C255.2, C256.2, C257.2, C258.2, U201.A2 (GND), U201.A12 (GND), U201.B5 (GND), U201.B15 (GND), U201.C8 (GND), U201.C18 (GND), U201.D1 (GND), U201.D11 (GND), U201.E4 (GND), U201.E14 (GND), U201.F7 (GND), U201.F9 (GND), U201.F11 (GND), U201.F17 (GND), U201.G8 (GND), U201.G10 (GND), U201.G12 (GND), U201.H3 (GND), U201.H7 (GND), U201.H9 (GNDADC_0), U201.H11 (GND), U201.H13 (GND), U201.J6 (GND), U201.J8 (GND), U201.J12 (GND), U201.J16 (GND), U201.K7 (GND), U201.K11 (GND), U201.L2 (GND), U201.L8 (GND), U201.L12 (GND), U201.M5 (GND), U201.M7 (GND), U201.M9 (GND), U201.M11 (GND), U201.M15 (GND), U201.N8 (GND), U201.N10 (GND), U201.N12 (GND), U201.N18 (GND), U201.P1 (GND), U201.R4 (GND), U201.R14 (GND), U201.T7 (GND), U201.T17 (GND), U201.U10 (GND), U201.V3 (GND), U201.V13 (GND); also elsewhere on the board
unnamed: C201.1, FB201.2, U201.H10 (VCCADC_0)

Notes on the sheet:
FPGA Power [2]
FPGA Power

## Commit log

2025-10-16 Protocol Specifications were added to README.md
2025-10-17 Added an image to the README before consultation
2025-10-23 Updated README.md with protcol structures and added details regarding the communication parameters. New images explaining the structures were added.
2025-10-24 Introduced KiCad project files for the sensor side FPGA board design
2025-11-06 Created the Hardware Design section outlining the hardware design process. Added section for controlled impedance calculation and included a High Level Overview section with a block diagram of the sy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
2025-11-07 Minor Changes to the README. Added folder for firmware and added the FPGA footprint library
2025-11-10 Finished the FPGA Pinout in KiCad and started routing the Power section. Created the TinyFPGA_BringUp project in iCEcube2 IDE to test familiarize myself with the Lattice toolchain.
2025-11-10 Highlighted points for a scheduled meeting regarding the protocol design.
2025-11-11 Added a small detail regarding the meeting
2025-11-21 Added schematic sections and advanced the design. Advanced the development of Verilog code, for TinyFPGA bringup (however, still not working). Cosmetic changes in README.
2025-12-04 Finished the schematic design.
2025-12-04 Finished the schematic.
2025-12-05 Cleared ERC errors and improved folder structure
2025-12-09 Fixed minor bugs in the schematic and updated the documentation.
2025-12-09 Fixed LaTeX Mardkdown rendering issues.
2025-12-13 Added a programmer schematic
2025-12-18 Added documantation regarding the programmer board and updated the PDF schematics.
2025-12-21 Pushing before updating KiCad
2025-12-22 Routing and Schematic update
2025-12-23 Finised the design of the sensor board :)
2025-12-26 Routed the programmer board
2025-12-26 Finished design of both programmer and sensor board PCBs
2025-12-28 Finished final PCB checks before manufacturing and uploaded the fabrication files
2025-12-29 Updated documentation and finished first iteration of PCB rework based on manufacturer feedback.
2026-01-03 Commited the final manufacturing files, as well as updated the documentation
2026-01-15 Added comments to the schematic, updated documentation with the board bringup, and wrote the VoxLink Verilog blink sketch.
2026-01-15 Didn't close all the applications, so committing again with all the files saved.
2026-01-15 Finding out how to sync the project
2026-01-15 Fixing the video preview of the fpga_blink file
2026-02-25 * Created an I2C driver and a basic BNO protocol sequence implementation reading the advertisement message. * Created a Vivado project with simulation for the iCE40UL1K FPGA.
2026-02-25 Added the BNO Subscription Stage in the BNO Driver
2026-02-25 Updated the doucmentation with an HDL log
2026-02-27 BNO Driver Update Updated the BNO driver to handle the initial advertisement packets. This feature is not completely tested as of this commit!
2026-02-28 Updated the data readout logic in the BNO driver.
2026-03-05 Working sensor readout. Clean up tomorrow
2026-03-06 Finished testing the readout. Uploaded the correct Vivado Vox Readout files. Please note that the testing Vox files were copied from another directory and may require assigning new paths in Vivado.
2026-03-07 Controller Development Initialization Began designing the power stage for the controller board.
2026-03-09 Updated the domcumentation
2026-03-09 Updated the documentation
2026-03-10 Commited Schematic Changes
2026-03-10 Updated schematic diagram with configuration
2026-03-11 Added new sheets to the schematic
2026-03-11 Added USB hub symbol
2026-03-12 Updated the schematic design - Fix the XC7A35T-CPG236 outline issue
2026-03-13 Fixed the bug in the FPGA symbol I have unchecked these boxes in the symbol properties and settings for the individual shapes -All units are interchangeable -Common to all units
2026-03-13 Finished schematic design - preparation for review
2026-03-16 Finished DRC check. Moving to schematic review
2026-03-17 Finished the schematic review
2026-03-17 Updated the documentation + minor scheme changes - Documented the schematic design - Added zener diode from USB VBUS to 5V
2026-03-20 Started schematic rework and the PCB design
2026-03-21 Commit before upgrading to KiCad 10.0
2026-03-21 Converted to 10.0 KiCad schematic + Began BGA fan
2026-03-22 Advanced PCB routing and reorganized FPGA traces
2026-03-23 Commiting PCB design with 45 degree tracks
2026-03-23 Advanced PCB design: Routed FTDIs + SPI Flash
2026-03-24 Advanced PCB design - Routed FTDI chips + USB HUB
2026-03-25 Advanced PCB design: Advanced power routing
2026-03-26 Advanced PCB Design: Routing Power + UVLO
2026-03-28 Finished PCB Design - WARNING MORE CHANGES NEEDED! The main decision to be made is, whether to increase the layer count to 8 layers, and make the P7 and P8 permamently on 3V3
2026-03-31 Finished Lattice Core Module Development-NO REVIEW
2026-03-31 Commit with restored changes after KiCad crash
2026-03-31 Wrapping up for today. Almost reworked core module
2026-04-01 Finished Lattice Core, waiting for PCB Review
2026-04-01 Advanced Intel Core Module Development
2026-04-02 Finished All Schemes, Waiting for Design Review !!! CONTROLLER BOARD STILL NEEDS TO HAVE THE POWER SECTION UPDATED !!! + programmer PCB needed
2026-04-03 Generated manufacturing files for Module boards
2026-04-05 Finished procuring almost all boards - CHANGED XDC IN XILINX FOR TESTING!! - Programmer needed
2026-04-09 Finished PCB design and Review + Procured Boards
2026-04-12 Wrote FPGA CRC logic based on Koopman's approach
2026-04-14 Commiting Block 1 progress. Finished CRC and Time
2026-04-20 Fixed bug in plottying.py + updated KiCad 9 files
2026-04-22 Implemented CRC onto the Xilinx FPGA + bug fixes
2026-04-26 Referenced XDC pins to silkscreen
2026-04-28 Commit before changing Git folder absolute path - Changes in the reg_multiplexer data width not reflected from the current version - Apparently I don't have CRC implemented
2026-04-28 Succesfully changed directories
2026-04-29 Fixed sensor spiking by implementing Core I2C CDC - Latest version of the single VoxNode implementation - Final commit before multinode firmware development
2026-04-29 Recommiting previous commit with more files
2026-04-30 Committed double Ethernet sensing! + Added magic
2026-05-01 Advanced Multinode Development - Added FIFO - Commiting before FIFO reset addition update
2026-05-02 Fixed protocol retransmission logic with timeout
2026-05-02 Implemented initialization packet logic
2026-05-03 Finished initialization sequence integration. - Now, Python can ask the Controller Baord the number of nodes after initialization
2026-05-03 Commented a lot of code + append logic implement.
2026-05-04 First working iteration of the Multinode Protocol - Debugging and testing still needed - Tested only for 2 board - Currently, the Python code requests each sensor data: make a common readout for all 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
2026-05-05 Updated BRAM + cleared warnings in Vivado
2026-05-05 Changed readout type to burst mode
2026-05-06 VoxLink was made to run at 21MHz - timing issues
2026-05-07 New firmware which is difficult to brick - I don't know what has happened, but the amount of EMI bricks reduced dramatically after I added the NACK sticky connection to the LED - Also connected BNO N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
2026-05-07 Added controller timeout and rollbacked Lattice - Added controller timeout - Rollbacked lattice to the last commit but git treats files as new additions - Added plotting software
2026-05-12 Added measurement scripts and measured data - Committing Voxel Tower Measurements
2026-05-13 Created Lattice Eye Diagram Measureing Firmware - New Lattice iCEcube2 project added - Measured eye diagram in Software/Data/EyeDiagram_6.png
