# Repository MichalVarsanyi/VoxLink (continued)

## KiCad design Hardware/Sensor_Board/VoxSense.kicad_pcb (continued)

Parts:
C201, C202, C203, C204, C205, C206: 1u; C_0402_1005Metric
C207, C210, C214, C216, C217: 100n; C_0402_1005Metric
C208: 33n; C_0402_1005Metric
C209, C213, C215: 4u7; C_0603_1608Metric
C211: 4u7; C_0805_2012Metric; not fitted
C212: 100n; C_0402_1005Metric; not fitted
R201: 10k; R_0402_1005Metric
R202: 100R; R_0402_1005Metric; not fitted
U201: TPS7A20L_1V2; Texas_X2SON-4_1x1mm_P0.65mm
U202: TPS7A20L_2V2; Texas_X2SON-4_1x1mm_P0.65mm
U203: TPS7A20L_3V3; Texas_X2SON-4_1x1mm_P0.65mm
U204: TLV840MADL; SOT-23-5
U301: ICE40UL1K-CM36AI; UCBGA-36_2.5x2.5mm_Layout6x6_P0.4mm

Connections:
+1V2_CORE: C202.1, C207.1, C209.1, C210.1, C211.1, C212.1, R202.1, R202.2, U201.1 (OUT), U203.3 (EN), U204.2 (VDD), U301.D3 (VCC), U301.D4 (VCCPLL)
+2V5_NVCM: C204.1, C213.1, C214.1, U202.1 (OUT), U301.B4 (VPP2V5)
+3V3: C206.1, C215.1, C216.1, C217.1, R201.1, U202.3 (EN), U203.1 (OUT), U301.B3 (VCCIO0), U301.E3 (VCCIO2), U301.E4 (SPI_VCCIO1); also elsewhere on the board
+5V: C201.1, C203.1, C205.1, U201.3 (EN), U201.4 (IN), U202.4 (IN), U203.4 (IN); also elsewhere on the board
/Power/CT: C208.1, U204.5 (CT)
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, U201.2 (GND), U201.5 (Pad), U202.2 (GND), U202.5 (Pad), U203.2 (GND), U203.5 (Pad), U204.3 (GND), U301.C3 (GND), U301.C4 (GND), U301.C5 (GND_LED); also elsewhere on the board
~CRESET: R201.2, U204.1 (~RESET); also elsewhere on the board

Notes on the sheet:
Power [2]
C [uF] = (T_delay [uS] - 80uS) / 618937 32nF = (20,000us - 80uS) / 618937
Note that ~{CRESET} is active LOW, meaning the FPGA is active when ~{CRESET} is HIGH. This requires a ~{RESET} variant of the TLV840 chip which active LOW, meaning it is the correct reset logic.
Keep close to the FPGA pads!
The NVCM regulator can be omitted and the VPP2V5 pin can be connected directly to 3V3 in order to save cost. The pin can handle 3.6V. A diode can be used to drop the voltage before by roughly 0.7V
The FPGA wakes up after rougly 10us, however, the memory takes 150us to boot. We need to delay the FPGA startup, so that the flash memory is ready.
Filtering suggested by the manufacturer
Multiple net names are used to indicate the I/O banks throughout the schematic
Due to tight BGA fanout, the 1V2_CORE and 1V2_PLL have to be connected together.
EN_HIGH = 0.9V EN_LOW = 0.3V EN_MAX = 6.5V
U204 is removed in the prototype version
FPGA Power Input
IO Supply
Core Supply Voltage
NVCM Supply
FPGA Power Delay

Parts:
C401, C402, C403: 100n; C_0402_1005Metric
C404, C405: 15pF; C_0402_1005Metric
R401, R402, R406, R407: 4k7; R_0402_1005Metric
R403, R404, R405: 10k; R_0402_1005Metric
R408: 22R; R_0402_1005Metric
U301: ICE40UL1K-CM36AI; UCBGA-36_2.5x2.5mm_Layout6x6_P0.4mm
U401: BNO086; LGA-28_5.2x3.8mm_P0.5mm
Y401: 32.768 kHz; Crystal_SMD_MicroCrystal_CC8V-T1A-2Pin_2.0x1.2mm

Connections:
+3V3: C401.1, C402.1, R401.1, R402.1, R403.1, R404.1, R405.1, R406.1, R407.1, U401.3 (VDD), U401.28 (VDDIO); also elsewhere on the board
/Sensor/XIN32: C404.1, U401.27 (XIN32), Y401.2
/Sensor/XOUT32: R408.1, U401.26 (XOUT32)
/Sensor/XOUT32_INT: C405.1, R408.2, Y401.1
BNO_SCL: R402.2, U301.C6 (IOT_22B_G0), U401.19 (H_SCL/SCK/RX)
BNO_SDA: R401.2, U401.20 (H_SDA/H_MISO/TX); also elsewhere on the board
BNO_~RST: R405.2, U301.B6 (IOT_21A_G1), U401.11 (~RST)
GND: C401.2, C402.2, C403.2, C404.2, C405.2, U401.2 (GND), U401.5 (PS1), U401.6 (PS0/WAKE), U401.10 (CLKSEL0), U401.25 (GND); also elsewhere on the board
unnamed: C403.1, U401.9 (CAP)
unnamed: R407.2, U401.15 (ENV_SCL)
unnamed: R406.2, U401.16 (ENV_SDA)
unnamed: R404.2, U401.17 (SA0/H_MOSI)
unnamed: R403.2, U401.4 (~BOOT)

Notes on the sheet:
CLKSEL0 = LOW for external clock
I2C Address Selection HIGH = 0x4B LOW = 0x4A
Keep close to IC pads!
For daisy-chaining temperatre/humidity sensors. Even unused needs to be teminated with pullup resistors as per the I2C standard!
CEVA recommends using a crystal with tolerance 50ppm with 12.5pF capacitor loading.
Sensor [4]
Interrupt to host device Only for SPI
NEXT REVISION: Connect ~{H_INT} to FPGA!
(12.5pF Load Capacitance - 5pF Stray Capacitance) * 2 = 15pF Load Capacitors
I2C Interface
BNO086 Crystal
BNO086

Parts:
C301, C302, C303, C304: 100n; C_0402_1005Metric
D301, D303, D304: TVS; D_0402_1005Metric
D302: Schottky; D_0402_1005Metric
D305, D308: LED; LED_0603_1608Metric
D306: RX; LED_0603_1608Metric
D307: TX; LED_0603_1608Metric
J301: TC2030-NL; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J302: PicoBlade; Molex_PicoBlade_53048-0810_1x08_P1.25mm_Horizontal
R301: 4x22R; EXBN8V101JX
R302: 22R; R_0402_1005Metric
R303, R306, R307, R308: 510R; R_0402_1005Metric
R304, R305: 10k; R_0402_1005Metric
SW301: Reset; SW_Push_SPST_NO_Alps_SKRK
U301: ICE40UL1K-CM36AI; UCBGA-36_2.5x2.5mm_Layout6x6_P0.4mm
U302: TPD4E02B04; USON-10_2.5x1.0mm_P0.5mm__Reduced_Paste
U305: N25Q032A; U-PDFN-8
Y301: 12MHz; Oscillator_SMD_Abracon_ASCO-4Pin_1.6x1.2mm

Connections:
12MHZ_CLK: R302.1; also elsewhere on the board
+3V3: C302.1, C303.1, R303.1, R304.1, R305.1, R306.1, R307.1, R308.1, U305.8 (VCC), Y301.1 (Tri-State), Y301.4 (VDD); also elsewhere on the board
/System/CDONE: D303.1 (A1), D308.2 (A), J302.3, R303.2, U301.D5 (IOB_11B_CDONE)
/System/FLASH_MISO: R301.3, U301.E5 (IOB_15B_SI), U305.2 (SDO)
/System/FLASH_MISO_NOESD: J301.2 (SWDIO), J302.5, R301.6, U302.2 (IN), U302.9 (NC)
/System/FLASH_MOSI: R301.2, U301.F6 (IOB_14A_SO), U305.5 (SDI)
/System/FLASH_MOSI_NOESD: J301.4 (SWCLK), J302.6, R301.7, U302.4 (IN), U302.7 (NC)
/System/FLASH_SCK: R301.4, U301.E6 (IOB_16A_SCK), U305.6 (SCK)
/System/FLASH_SCK_NOESD: J301.6 (SWO), J302.4, R301.5, U302.1 (IN), U302.10 (NC)
/System/FLASH_~CS: R301.1, U301.F5 (IOB_17B_SS), U305.1 (~CS)
/System/FLASH_~CS_NOESD: J301.3 (~RESET), J302.7, R301.8, U302.5 (IN), U302.6 (NC)
/System/FLASH_~HOLD: R305.2, U305.7 (~HOLD)
/System/FLASH_~WP: R304.2, U305.3 (~WP)
/System/LED: D305.1 (K), U301.A2 (RGB0)
/System/OSC_OUT: R302.2, Y301.3 (OUT)
/System/RX_LED: D306.1 (K), U301.B1 (RGB1)
/System/TX_LED: D307.1 (K), U301.A1 (RGB2)
GND: C301.2, C302.2, C303.2, C304.2, D301.2 (A2), D303.2 (A2), D304.2 (A2), D308.1 (K), J301.5 (GND), J302.1, SW301.2, U302.3 (GND), U302.8 (NC), U305.4 (GND), Y301.2 (GND); also elsewhere on the board
unnamed: D305.2 (A), R306.2
unnamed: D306.2 (A), R307.2
unnamed: D307.2 (A), R308.2
VCC: D302.1 (K); also elsewhere on the board
VCCD: C301.1, D301.1 (A1), D302.2 (A), J301.1 (VCC), J302.8
~CRESET: C304.1, D304.1 (A1), J302.2, SW301.1, U301.F4 (~CRESET); also elsewhere on the board

Notes on the sheet:
D302 is removed in the prototype version
Used for LED driving
Part choice may be subject to change in the next revision
If the LED shines, the device has been configured properly
See: iCE40 Programming and Configuration app note Section 9.2. SPI PROM Requirements
VCCIO1 = 3V3
CDONE is an Open-Drain Output which goes high after the device has been configured successfully
NEXT REVISION: There is an imbalance of 22R resistors! No resistors on the CDONE and ~{CRESET}
System [3]
FPGA Manual Reset
Chip is active when ~{CRESET} is LOW
VCCIO0 = 3V3
WARNING: Connector is FLIPPED to match polarity!
ESD Protection IC
Open-Drain Outputs
SPI Flash
External Oscillator
Tag Connect Programming Interface
PicoBlade Programming Connector

Board: 4 copper layers, 85.0 x 15.7 mm, 93 parts (2 on the bottom side), 59 nets.

## KiCad design Hardware/Sensor_Module/Sensor_Module.kicad_pcb

Notes on the sheet:
Technical Sheet Only! Please refer to the subsequent sheets for schematic
Root [0]

Parts:
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13: TVS; WLL-2-3; LCSC C2939949
J1: Connector_Left; 7-Pin_Casselated_Edge
J2: Connector_Right; 7-Pin_Casselated_Edge

Connections:
+3V3: D11.2 (A2), J2.2; also elsewhere on the board
+5V: D2.2 (A2), J1.6; also elsewhere on the board
BNO_ADDR: D10.2 (A2), J2.3; also elsewhere on the board
BNO_SCL: D3.2 (A2), J1.5; also elsewhere on the board
BNO_SDA: D4.2 (A2), J1.4; also elsewhere on the board
BNO_~RST: D5.2 (A2), J1.3; also elsewhere on the board
ENV_SCL: D9.2 (A2), J2.4; also elsewhere on the board
ENV_SDA: D8.2 (A2), J2.5; also elsewhere on the board
GND: D2.1 (A1), D3.1 (A1), D4.1 (A1), D5.1 (A1), D6.1 (A1), D7.1 (A1), D8.1 (A1), D9.1 (A1), D10.1 (A1), D11.1 (A1), D12.1 (A1), D13.1 (A1), J1.7, J2.1; also elsewhere on the board
NC1: D13.2 (A2), J2.6
NC2: D12.2 (A2), J2.7
~H_CS: D7.2 (A2), J1.1; also elsewhere on the board
~H_INT: D6.2 (A2), J1.2; also elsewhere on the board

Notes on the sheet:
Connectivity [2]
ESD Protection
Edge Connectors

Parts:
C1, C2, C5: 100n; C_0402_1005Metric; LCSC C77020
C3, C4: 4.7u; C_0402_1005Metric; LCSC C2858031
C6, C7: 15pF; C_0402_1005Metric; LCSC C2169087
D1: LED; LED_0402_1005Metric; LCSC C7466700
R1, R2, R5, R6: 4k7; R_0402_1005Metric; LCSC C482193
R3, R4, R8: 10k; R_0402_1005Metric; LCSC C71617
R7: 510R; R_0402_1005Metric; LCSC C482201
R9: 22R; R_0402_1005Metric; LCSC C482106
U1: BNO086; LGA-28_5.2x3.8mm_P0.5mm; LCSC C5264422
U2: TPS7A20L_3V3; Texas_X2SON-4_1x1mm_P0.65mm; LCSC C22445532
Y1: 32.768 kHz; Crystal_SMD_MicroCrystal_CM9V-T1A-2Pin_1.6x1.0mm; LCSC C5154201

Connections:
+3V3: C1.1, C2.1, C4.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U1.3 (VDD), U1.28 (VDDIO), U2.1 (OUT); also elsewhere on the board
+5V: C3.1, U2.3 (EN), U2.4 (IN); also elsewhere on the board
/Sensor/XIN32: C6.1, U1.27 (XIN32), Y1.2
/Sensor/XOUT32: R9.1, U1.26 (XOUT32)
/Sensor/XOUT32_INT: C7.1, R9.2, Y1.1
BNO_ADDR: R3.2, U1.17 (SA0/H_MOSI); also elsewhere on the board
BNO_SCL: R2.2, U1.19 (H_SCL/SCK/RX); also elsewhere on the board
BNO_SDA: R1.2, U1.20 (H_SDA/H_MISO/TX); also elsewhere on the board
BNO_~RST: R4.2, U1.11 (~RST); also elsewhere on the board
ENV_SCL: R6.2, U1.15 (ENV_SCL); also elsewhere on the board
ENV_SDA: R5.2, U1.16 (ENV_SDA); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D1.1 (K), U1.2 (GND), U1.5 (PS1), U1.6 (PS0/WAKE), U1.10 (CLKSEL0), U1.25 (GND), U2.2 (GND), U2.5 (Pad); also elsewhere on the board
unnamed: D1.2 (A), R7.2
unnamed: C5.1, U1.9 (CAP)
unnamed: R8.2, U1.4 (~BOOT)
~H_CS: U1.18 (~H_CS); also elsewhere on the board
~H_INT: U1.14 (~H_INT); also elsewhere on the board

Notes on the sheet:
CEVA recommends using a crystal with tolerance 50ppm with 12.5pF capacitor loading.
Sensor [1]
For daisy-chaining temperatre/humidity sensors. Even unused needs to be teminated with pullup resistors as per the I2C standard!
(12.5pF Load Capacitance - 5pF Stray Capacitance) * 2 = 15pF Load Capacitors
I2C Address Selection HIGH = 0x4B LOW = 0x4A
CLKSEL0 = LOW for external clock
Keep close to IC pads!
BNO086 Crystal
BNO086
IO Supply

Board: 4 copper layers, 13.0 x 13.0 mm, 34 parts (0 on the bottom side), 19 nets.

File Hardware/Sensor_Module/gerber/Sensor_Module_BOM.csv:

Designator,Qty,Comment,DNP,Exclude from BOM,Exclude from Board,LCSC,Footprint,Datasheet,Manufacturer
"C1,C2,C5",3,100n,,,,C77020,Capacitor_SMD:C_0402_1005Metric,https://www.lcsc.com/product-detail/C77020.html,Murata
"C3,C4",2,4.7u,,,,C2858031,Capacitor_SMD:C_0402_1005Metric,https://www.lcsc.com/product-detail/C2858031.html,Murata
"C6,C7",2,15pF,,,,C2169087,Capacitor_SMD:C_0402_1005Metric,https://www.lcsc.com/product-detail/C2169087.html,Murata
D1,1,LED,,,,C7466700,LED_SMD:LED_0402_1005Metric,https://www.lcsc.com/product-detail/C7466700.html,Broadcom
"D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13",12,TVS,,,,C2939949,Custom_VoxLink_Footprints:WLL-2-3,https://www.lcsc.com/product-detail/C2939949.html,Infineon
"R1,R2,R5,R6",4,4k7,,,,C482193,Resistor_SMD:R_0402_1005Metric,https://www.lcsc.com/product-detail/C482193.html,Vishay
"R3,R4,R8",3,10k,,,,C71617,Resistor_SMD:R_0402_1005Metric,https://www.lcsc.com/product-detail/C71617.html,Vishay
R7,1,510R,,,,C482201,Resistor_SMD:R_0402_1005Metric,https://www.lcsc.com/product-detail/C482201.html,Vishay
R9,1,22R,,,,C482106,Resistor_SMD:R_0402_1005Metric,https://www.lcsc.com/product-detail/C482106.html,Vishay
U1,1,BNO086,,,,C5264422,Package_LGA:LGA-28_5.2x3.8mm_P0.5mm,https://eu.mouser.com/ProductDetail/CEVA/BNO086?qs=ulEaXIWI0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,CEVA
U2,1,TPS7A20L_3V3,,,,C22445532,Package_SON:Texas_X2SON-4_1x1mm_P0.65mm,https://www.mouser.sk/ProductDetail/Texas-Instruments/TPS7A2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,TI
Y1,1,32.768 kHz,,,,C5154201,Crystal:Crystal_SMD_MicroCrystal_CM9V-T1A-2Pin_1.6x1.0mm,https://www.lcsc.com/product-detail/C5154201.html,Epson

## KiCad design Hardware/Shell_Module_BUS/Shell_Module_BUS.kicad_pcb

Parts:
C1: 10u; C_1206_3216Metric; LCSC C77092
C304: 1u; C_0603_1608Metric; LCSC C85862
H1, H2: M3; MountingHole_3.2mm_M3_DIN965
J1: PicoBlade; Molex_PicoBlade_53048-0810_1x08_P1.25mm_Horizontal
J2: RJ45_Output; CONN_855035-101_MOL
R1: 1R; R_0603_1608Metric; LCSC C445774
R2: 10k; R_0603_1608Metric; LCSC C844918
SW301: Reset; SW_TH_Tactile_Omron_B3F-102x
U1: VoxLink_Core_Module
U2: VoxLink_BNO086_Module

Connections:
+3V3: R2.1, U2.9 (+3V3)
+5V: C1.1, J1.5, J2.3 (VCC), U1.26 (5V), U2.2 (5V)
/BNO_NINT: U1.20 (IOB_1B), U2.6 (H_NINT)
/BNO_NRST: U1.21 (IOT_18B), U2.5 (BNO_NRST)
/BNO_SCL: U1.23 (IOT_5B), U2.3 (BNO_SCL)
/BNO_SDA: U1.22 (IOT_4A), U2.4 (BNO_SDA)
/CLK_N: J1.1, J2.5 (~CLK), U1.12 (IOT_24B)
/CLK_P: J1.2, J2.4 (CLK), U1.13 (IOT_21A_G1)
/NRESET: C304.1, R2.2, SW301.1, U1.1 (NRESET)
/RX_N: J1.8, J2.2 (~RX), U1.7 (IOT_25A)
/RX_P: J1.7, J2.1 (RX), U1.8 (IOT_19A)
/TX_N: J1.3, J2.7 (~TX), U1.15 (IO_10A)
/TX_P: J1.4, J2.8 (TX), U1.14 (IOT_22B_G0)
GND: C304.2, J1.6, J2.6 (GND), J2.9 (SHD), J2.10 (SHD), R1.2, SW301.2, U1.27 (GND), U2.1 (GND), U2.8 (GND)
unnamed: C1.2, R1.1

Notes on the sheet:
VoxLink color coding with the BotBlox 8-way cable
Connector is Facing Left
Shell Module Bus
INPUT
OUTPUT
FPGA Manual Reset
Mounting Holes
Lattice Core Module
BNO086 Sensor Module
VoxLink Connectors

Board: 4 copper layers, 54.0 x 29.5 mm, 11 parts (5 on the bottom side), 15 nets.
